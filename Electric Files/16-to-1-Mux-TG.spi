*** SPICE deck for cell 16-to-1-Mux-TG{lay} from library 16-to-1-Mux
*** Created on Thu Nov 07, 2019 16:17:54
*** Last revised on Mon Nov 11, 2019 20:03:39
*** Written on Wed Nov 13, 2019 12:05:29 by Electric VLSI Design System, version 9.07
*** Layout tech: mocmos, foundry MOSIS
*** UC SPICE *** , MIN_RESIST 4.0, MIN_CAPAC 0.1FF
***    P-Active:	areacap=0.9FF/um^2,	edgecap=0.0FF/um,	res=2.5ohms/sq
***    N-Active:	areacap=0.9FF/um^2,	edgecap=0.0FF/um,	res=3.0ohms/sq
***    Polysilicon-1:	areacap=0.1467FF/um^2,	edgecap=0.0608FF/um,	res=6.2ohms/sq
***    Polysilicon-2:	areacap=1.0FF/um^2,	edgecap=0.0FF/um,	res=50.0ohms/sq
***    Transistor-Poly:	areacap=0.09FF/um^2,	edgecap=0.0FF/um,	res=2.5ohms/sq
***    Poly-Cut:	areacap=0.0FF/um^2,	edgecap=0.0FF/um,	res=2.2ohms/sq
***    Active-Cut:	areacap=0.0FF/um^2,	edgecap=0.0FF/um,	res=2.5ohms/sq
***    Metal-1:	areacap=0.1209FF/um^2,	edgecap=0.1104FF/um,	res=0.078ohms/sq
***    Via1:	areacap=0.0FF/um^2,	edgecap=0.0FF/um,	res=1.0ohms/sq
***    Metal-2:	areacap=0.0843FF/um^2,	edgecap=0.0974FF/um,	res=0.078ohms/sq
***    Via2:	areacap=0.0FF/um^2,	edgecap=0.0FF/um,	res=0.9ohms/sq
***    Metal-3:	areacap=0.0843FF/um^2,	edgecap=0.0974FF/um,	res=0.078ohms/sq
***    Via3:	areacap=0.0FF/um^2,	edgecap=0.0FF/um,	res=0.8ohms/sq
***    Metal-4:	areacap=0.0843FF/um^2,	edgecap=0.0974FF/um,	res=0.078ohms/sq
***    Via4:	areacap=0.0FF/um^2,	edgecap=0.0FF/um,	res=0.8ohms/sq
***    Metal-5:	areacap=0.0843FF/um^2,	edgecap=0.0974FF/um,	res=0.078ohms/sq
***    Via5:	areacap=0.0FF/um^2,	edgecap=0.0FF/um,	res=0.8ohms/sq
***    Metal-6:	areacap=0.0423FF/um^2,	edgecap=0.1273FF/um,	res=0.036ohms/sq
***    Hi-Res:	areacap=0.0FF/um^2,	edgecap=0.0FF/um,	res=1.0ohms/sq

*** TOP LEVEL CELL: 16-to-1-Mux-TG{lay}
Mnmos@40 net@963 net@909#3nmos@40_poly-left D0 gnd NMOS L=0.35U W=1.75U AS=1.991P AD=1.991P PS=5.775U PD=5.775U
Mnmos@41 net@963 S0#0nmos@41_poly-left D1 gnd NMOS L=0.35U W=1.75U AS=1.991P AD=1.991P PS=5.775U PD=5.775U
Mnmos@42 net@931 net@909#18nmos@42_poly-right D2 gnd NMOS L=0.35U W=1.75U AS=1.991P AD=1.991P PS=5.775U PD=5.775U
Mnmos@43 net@931 S0#14nmos@43_poly-left D3 gnd NMOS L=0.35U W=1.75U AS=1.991P AD=1.991P PS=5.775U PD=5.775U
Mnmos@44 net@962 net@930 net@963 gnd NMOS L=0.35U W=1.75U AS=1.991P AD=1.991P PS=5.775U PD=5.775U
Mnmos@45 net@962 S1#3nmos@45_poly-left net@931 gnd NMOS L=0.35U W=1.75U AS=1.991P AD=1.991P PS=5.775U PD=5.775U
Mnmos@46 net@930#4contact@368_metal-1-metal-2 S1#6pin@316_polysilicon-1 gnd gnd NMOS L=0.35U W=1.75U AS=15.772P AD=1.991P PS=43.4U PD=5.775U
Mnmos@47 net@909#10contact@360_metal-1-n-act S0#8nmos@47_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=15.772P AD=1.991P PS=43.4U PD=5.775U
Mnmos@48 net@1144 net@1090#3nmos@48_poly-left D4 gnd NMOS L=0.35U W=1.75U AS=1.991P AD=1.991P PS=5.775U PD=5.775U
Mnmos@49 net@1144 S0#18nmos@49_poly-left D5 gnd NMOS L=0.35U W=1.75U AS=1.991P AD=1.991P PS=5.775U PD=5.775U
Mnmos@50 net@1112 net@1090#18nmos@50_poly-right D6 gnd NMOS L=0.35U W=1.75U AS=1.991P AD=1.991P PS=5.775U PD=5.775U
Mnmos@51 net@1112 S0#32nmos@51_poly-left D7 gnd NMOS L=0.35U W=1.75U AS=1.991P AD=1.991P PS=5.775U PD=5.775U
Mnmos@52 net@1143 net@1111 net@1144 gnd NMOS L=0.35U W=1.75U AS=1.991P AD=1.991P PS=5.775U PD=5.775U
Mnmos@53 net@1143 S1#16nmos@53_poly-left net@1112 gnd NMOS L=0.35U W=1.75U AS=1.991P AD=1.991P PS=5.775U PD=5.775U
Mnmos@54 net@1111#4contact@434_metal-1-metal-2 S1#19pin@374_polysilicon-1 gnd gnd NMOS L=0.35U W=1.75U AS=15.772P AD=1.991P PS=43.4U PD=5.775U
Mnmos@55 net@1090#10contact@426_metal-1-n-act S0#26nmos@55_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=15.772P AD=1.991P PS=43.4U PD=5.775U
Mnmos@56 net@1273 net@1276#15nmos@56_poly-left D8 gnd NMOS L=0.35U W=1.75U AS=1.991P AD=1.991P PS=5.775U PD=5.775U
Mnmos@57 net@1273 S0#70nmos@57_poly-left D9 gnd NMOS L=0.35U W=1.75U AS=1.991P AD=1.991P PS=5.775U PD=5.775U
Mnmos@58 net@1327 net@1276#12nmos@58_poly-right D10 gnd NMOS L=0.35U W=1.75U AS=1.991P AD=1.991P PS=5.775U PD=5.775U
Mnmos@59 net@1327 S0#46nmos@59_poly-left D11 gnd NMOS L=0.35U W=1.75U AS=1.991P AD=1.991P PS=5.775U PD=5.775U
Mnmos@60 net@1594 net@1271#6nmos@60_poly-left net@1273 gnd NMOS L=0.35U W=1.75U AS=1.991P AD=1.991P PS=5.775U PD=5.775U
Mnmos@61 net@1594 S1#49nmos@61_poly-left net@1327 gnd NMOS L=0.35U W=1.75U AS=1.991P AD=1.991P PS=5.775U PD=5.775U
Mnmos@62 net@1271 S1#26pin@432_polysilicon-1 gnd gnd NMOS L=0.35U W=1.75U AS=15.772P AD=1.991P PS=43.4U PD=5.775U
Mnmos@63 net@1276#2contact@492_metal-1-n-act S0#40nmos@63_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=15.772P AD=1.991P PS=43.4U PD=5.775U
Mnmos@64 net@1414 net@1360#3nmos@64_poly-left D12 gnd NMOS L=0.35U W=1.75U AS=1.991P AD=1.991P PS=5.775U PD=5.775U
Mnmos@65 net@1414 S0#52nmos@65_poly-left D13 gnd NMOS L=0.35U W=1.75U AS=1.991P AD=1.991P PS=5.775U PD=5.775U
Mnmos@66 net@1382 net@1360#18nmos@66_poly-right D14 gnd NMOS L=0.35U W=1.75U AS=1.991P AD=1.991P PS=5.775U PD=5.775U
Mnmos@67 net@1382 S0#66nmos@67_poly-left D15 gnd NMOS L=0.35U W=1.75U AS=1.991P AD=1.991P PS=5.775U PD=5.775U
Mnmos@68 net@1413 net@1381 net@1414 gnd NMOS L=0.35U W=1.75U AS=1.991P AD=1.991P PS=5.775U PD=5.775U
Mnmos@69 net@1413 S1#37nmos@69_poly-left net@1382 gnd NMOS L=0.35U W=1.75U AS=1.991P AD=1.991P PS=5.775U PD=5.775U
Mnmos@70 net@1381#4contact@566_metal-1-metal-2 S1#40pin@490_polysilicon-1 gnd gnd NMOS L=0.35U W=1.75U AS=15.772P AD=1.991P PS=43.4U PD=5.775U
Mnmos@71 net@1360#10contact@558_metal-1-n-act S0#60nmos@71_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=15.772P AD=1.991P PS=43.4U PD=5.775U
Mnmos@72 net@1632 net@1644#15nmos@72_poly-left net@962#12contact@597_metal-1-n-act gnd NMOS L=0.35U W=1.75U AS=1.991P AD=1.991P PS=5.775U PD=5.775U
Mnmos@73 net@1632 S2#16nmos@73_poly-left net@1143 gnd NMOS L=0.35U W=1.75U AS=1.991P AD=1.991P PS=5.775U PD=5.775U
Mnmos@74 net@1695 net@1644#12nmos@74_poly-right net@1594 gnd NMOS L=0.35U W=1.75U AS=1.991P AD=1.991P PS=5.775U PD=5.775U
Mnmos@75 net@1695 S2#10nmos@75_poly-left net@1413#12contact@609_metal-1-n-act gnd NMOS L=0.35U W=1.75U AS=1.991P AD=1.991P PS=5.775U PD=5.775U
Mnmos@76 Vout net@1637#7nmos@76_poly-left net@1632 gnd NMOS L=0.35U W=1.75U AS=1.991P AD=1.991P PS=5.775U PD=5.775U
Mnmos@77 Vout S3#10nmos@77_poly-left net@1695 gnd NMOS L=0.35U W=1.75U AS=1.991P AD=1.991P PS=5.775U PD=5.775U
Mnmos@78 net@1637 S3#0pin@548_polysilicon-1 gnd gnd NMOS L=0.35U W=1.75U AS=15.772P AD=1.991P PS=43.4U PD=5.775U
Mnmos@79 net@1644#2contact@624_metal-1-n-act S2#4nmos@79_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=15.772P AD=1.991P PS=43.4U PD=5.775U
Mpmos@40 D0 S0#2pmos@40_poly-left net@963 vdd PMOS L=0.35U W=1.75U AS=1.991P AD=1.991P PS=5.775U PD=5.775U
Mpmos@41 D1 net@909#2pmos@41_poly-left net@963 vdd PMOS L=0.35U W=1.75U AS=1.991P AD=1.991P PS=5.775U PD=5.775U
Mpmos@42 D2 S0#17pmos@42_poly-left net@931 vdd PMOS L=0.35U W=1.75U AS=1.991P AD=1.991P PS=5.775U PD=5.775U
Mpmos@43 D3 net@909#14pmos@43_poly-left net@931 vdd PMOS L=0.35U W=1.75U AS=1.991P AD=1.991P PS=5.775U PD=5.775U
Mpmos@44 net@963 S1#4pmos@44_poly-left net@962 vdd PMOS L=0.35U W=1.75U AS=1.991P AD=1.991P PS=5.775U PD=5.775U
Mpmos@45 net@931 net@930#2pmos@45_poly-left net@962 vdd PMOS L=0.35U W=1.75U AS=1.991P AD=1.991P PS=5.775U PD=5.775U
Mpmos@46 vdd S1#10pmos@46_poly-right net@930#4contact@368_metal-1-metal-2 vdd PMOS L=0.35U W=1.75U AS=1.991P AD=18.528P PS=5.775U PD=44.625U
Mpmos@47 vdd S0#6pmos@47_poly-right net@909#5contact@366_metal-1-metal-2 vdd PMOS L=0.35U W=1.75U AS=1.991P AD=18.528P PS=5.775U PD=44.625U
Mpmos@48 D4 S0#20pmos@48_poly-left net@1144 vdd PMOS L=0.35U W=1.75U AS=1.991P AD=1.991P PS=5.775U PD=5.775U
Mpmos@49 D5 net@1090#2pmos@49_poly-left net@1144 vdd PMOS L=0.35U W=1.75U AS=1.991P AD=1.991P PS=5.775U PD=5.775U
Mpmos@50 D6 S0#35pmos@50_poly-left net@1112 vdd PMOS L=0.35U W=1.75U AS=1.991P AD=1.991P PS=5.775U PD=5.775U
Mpmos@51 D7 net@1090#14pmos@51_poly-left net@1112 vdd PMOS L=0.35U W=1.75U AS=1.991P AD=1.991P PS=5.775U PD=5.775U
Mpmos@52 net@1144 S1#17pmos@52_poly-left net@1143 vdd PMOS L=0.35U W=1.75U AS=1.991P AD=1.991P PS=5.775U PD=5.775U
Mpmos@53 net@1112 net@1111#2pmos@53_poly-left net@1143 vdd PMOS L=0.35U W=1.75U AS=1.991P AD=1.991P PS=5.775U PD=5.775U
Mpmos@54 vdd S1#23pmos@54_poly-right net@1111#4contact@434_metal-1-metal-2 vdd PMOS L=0.35U W=1.75U AS=1.991P AD=18.528P PS=5.775U PD=44.625U
Mpmos@55 vdd S0#24pmos@55_poly-right net@1090#5contact@432_metal-1-metal-2 vdd PMOS L=0.35U W=1.75U AS=1.991P AD=18.528P PS=5.775U PD=44.625U
Mpmos@56 D8 S0#71pmos@56_poly-left net@1273 vdd PMOS L=0.35U W=1.75U AS=1.991P AD=1.991P PS=5.775U PD=5.775U
Mpmos@57 D9 net@1276#14pmos@57_poly-left net@1273 vdd PMOS L=0.35U W=1.75U AS=1.991P AD=1.991P PS=5.775U PD=5.775U
Mpmos@58 D10 S0#49pmos@58_poly-left net@1327 vdd PMOS L=0.35U W=1.75U AS=1.991P AD=1.991P PS=5.775U PD=5.775U
Mpmos@59 D11 net@1276#7pmos@59_poly-left net@1327 vdd PMOS L=0.35U W=1.75U AS=1.991P AD=1.991P PS=5.775U PD=5.775U
Mpmos@60 net@1273 S1#50pmos@60_poly-left net@1594 vdd PMOS L=0.35U W=1.75U AS=1.991P AD=1.991P PS=5.775U PD=5.775U
Mpmos@61 net@1327 net@1271#8pmos@61_poly-left net@1594 vdd PMOS L=0.35U W=1.75U AS=1.991P AD=1.991P PS=5.775U PD=5.775U
Mpmos@62 vdd S1#31pmos@62_poly-right net@1271 vdd PMOS L=0.35U W=1.75U AS=1.991P AD=18.528P PS=5.775U PD=44.625U
Mpmos@63 vdd S0#38pmos@63_poly-right net@1276 vdd PMOS L=0.35U W=1.75U AS=1.991P AD=18.528P PS=5.775U PD=44.625U
Mpmos@64 D12 S0#54pmos@64_poly-left net@1414 vdd PMOS L=0.35U W=1.75U AS=1.991P AD=1.991P PS=5.775U PD=5.775U
Mpmos@65 D13 net@1360#2pmos@65_poly-left net@1414 vdd PMOS L=0.35U W=1.75U AS=1.991P AD=1.991P PS=5.775U PD=5.775U
Mpmos@66 D14 S0#69pmos@66_poly-left net@1382 vdd PMOS L=0.35U W=1.75U AS=1.991P AD=1.991P PS=5.775U PD=5.775U
Mpmos@67 D15 net@1360#14pmos@67_poly-left net@1382 vdd PMOS L=0.35U W=1.75U AS=1.991P AD=1.991P PS=5.775U PD=5.775U
Mpmos@68 net@1414 S1#38pmos@68_poly-left net@1413 vdd PMOS L=0.35U W=1.75U AS=1.991P AD=1.991P PS=5.775U PD=5.775U
Mpmos@69 net@1382 net@1381#2pmos@69_poly-left net@1413 vdd PMOS L=0.35U W=1.75U AS=1.991P AD=1.991P PS=5.775U PD=5.775U
Mpmos@70 vdd S1#44pmos@70_poly-right net@1381#4contact@566_metal-1-metal-2 vdd PMOS L=0.35U W=1.75U AS=1.991P AD=18.528P PS=5.775U PD=44.625U
Mpmos@71 vdd S0#58pmos@71_poly-right net@1360#5contact@564_metal-1-metal-2 vdd PMOS L=0.35U W=1.75U AS=1.991P AD=18.528P PS=5.775U PD=44.625U
Mpmos@72 net@962#12contact@597_metal-1-n-act S2#17pmos@72_poly-left net@1632 vdd PMOS L=0.35U W=1.75U AS=1.991P AD=1.991P PS=5.775U PD=5.775U
Mpmos@73 net@1143 net@1644#14pmos@73_poly-left net@1632 vdd PMOS L=0.35U W=1.75U AS=1.991P AD=1.991P PS=5.775U PD=5.775U
Mpmos@74 net@1594 S2#13pmos@74_poly-left net@1695 vdd PMOS L=0.35U W=1.75U AS=1.991P AD=1.991P PS=5.775U PD=5.775U
Mpmos@75 net@1413#12contact@609_metal-1-n-act net@1644#7pmos@75_poly-left net@1695 vdd PMOS L=0.35U W=1.75U AS=1.991P AD=1.991P PS=5.775U PD=5.775U
Mpmos@76 net@1632 S3#11pmos@76_poly-left Vout vdd PMOS L=0.35U W=1.75U AS=1.991P AD=1.991P PS=5.775U PD=5.775U
Mpmos@77 net@1695 net@1637#9pmos@77_poly-left Vout vdd PMOS L=0.35U W=1.75U AS=1.991P AD=1.991P PS=5.775U PD=5.775U
Mpmos@78 vdd S3#5pmos@78_poly-right net@1637 vdd PMOS L=0.35U W=1.75U AS=1.991P AD=18.528P PS=5.775U PD=44.625U
Mpmos@79 vdd S2#2pmos@79_poly-right net@1644 vdd PMOS L=0.35U W=1.75U AS=1.991P AD=18.528P PS=5.775U PD=44.625U
** Extracted Parasitic Capacitors ***
C0 net@963 0 9.104fF
C1 D0 0 7.118fF
C2 D1 0 6.994fF
C3 net@931 0 8.084fF
C4 D2 0 7.043fF
C5 D3 0 7.02fF
C6 net@962 0 11.492fF
C7 net@930#4contact@368_metal-1-metal-2 0 14.629fF
C8 net@909#5contact@366_metal-1-metal-2 0 8.259fF
C9 net@909#10contact@360_metal-1-n-act 0 4.714fF
C10 S0#4contact@362_metal-1-metal-2 0 10.295fF
C11 S1#8contact@372_metal-1-metal-2 0 8.813fF
C12 net@1144 0 9.104fF
C13 D4 0 7.118fF
C14 D5 0 6.994fF
C15 net@1112 0 8.084fF
C16 D6 0 7.043fF
C17 D7 0 7.02fF
C18 net@1143 0 17.199fF
C19 net@1111#4contact@434_metal-1-metal-2 0 14.629fF
C20 net@1090#5contact@432_metal-1-metal-2 0 8.259fF
C21 net@1090#10contact@426_metal-1-n-act 0 4.714fF
C22 S0#22contact@428_metal-1-metal-2 0 16.852fF
C23 S1#21contact@438_metal-1-metal-2 0 15.152fF
C24 net@1273 0 9.104fF
C25 D8 0 7.118fF
C26 D9 0 6.994fF
C27 net@1327 0 8.084fF
C28 D10 0 7.043fF
C29 D11 0 7.02fF
C30 net@1594 0 16.809fF
C31 net@1271 0 14.629fF
C32 net@1276 0 8.259fF
C33 net@1276#2contact@492_metal-1-n-act 0 4.714fF
C34 S0#36contact@494_metal-1-metal-2 0 16.819fF
C35 S1#29contact@504_metal-1-metal-2 0 15.194fF
C36 net@1414 0 9.104fF
C37 D12 0 7.118fF
C38 D13 0 6.994fF
C39 net@1382 0 8.084fF
C40 D14 0 7.043fF
C41 D15 0 7.02fF
C42 net@1413 0 11.492fF
C43 net@1381#4contact@566_metal-1-metal-2 0 14.629fF
C44 net@1360#5contact@564_metal-1-metal-2 0 8.259fF
C45 net@1360#10contact@558_metal-1-n-act 0 4.714fF
C46 S0 0 11.814fF
C47 S1 0 10.003fF
C48 net@1632 0 9.104fF
C49 net@962#12contact@597_metal-1-n-act 0 15.538fF
C50 net@1695 0 8.084fF
C51 net@1413#12contact@609_metal-1-n-act 0 15.311fF
C52 Vout 0 7.462fF
C53 net@1637 0 14.629fF
C54 net@1644 0 8.259fF
C55 net@1644#2contact@624_metal-1-n-act 0 4.714fF
C56 S2#0contact@626_metal-1-metal-2 0 11.461fF
C57 S3#3contact@636_metal-1-metal-2 0 9.552fF
C58 S2 0 5.796fF
C59 S3 0 5.746fF
C60 S0#14nmos@43_poly-left 0 0.161fF
C61 S1#6pin@316_polysilicon-1 0 0.159fF
C62 S0#32nmos@51_poly-left 0 0.161fF
C63 S1#19pin@374_polysilicon-1 0 0.159fF
C64 S0#46nmos@59_poly-left 0 0.161fF
C65 S1#26pin@432_polysilicon-1 0 0.159fF
C66 S0#66nmos@67_poly-left 0 0.161fF
C67 S1#40pin@490_polysilicon-1 0 0.159fF
C68 S2#10nmos@75_poly-left 0 0.161fF
C69 S3#0pin@548_polysilicon-1 0 0.159fF
C70 S1#5pin@305_polysilicon-1 0 0.17fF
C71 S1#0pin@306_polysilicon-1 0 0.26fF
C72 S0#3pin@307_polysilicon-1 0 0.17fF
C73 S0#1pin@333_polysilicon-1 0 0.251fF
C74 S0#7pin@312_polysilicon-1 0 0.265fF
C75 net@909#16pin@326_polysilicon-1 0 0.125fF
C76 S1#2pin@315_polysilicon-1 0 0.17fF
C77 S1#11pin@318_polysilicon-1 0 0.168fF
C78 net@909#15pin@325_polysilicon-1 0 0.165fF
C79 S0#15pin@327_polysilicon-1 0 0.169fF
C80 net@909#1pin@330_polysilicon-1 0 0.204fF
C81 S0#16pin@331_polysilicon-1 0 0.25fF
C82 net@909 0 0.251fF
C83 net@909#4pin@335_polysilicon-1 0 0.24fF
C84 net@930#1pin@339_polysilicon-1 0 0.153fF
C85 net@930#3pin@340_polysilicon-1 0 0.156fF
C86 net@930#6pin@342_polysilicon-1 0 0.194fF
C87 S1#1pin@343_polysilicon-1 0 0.168fF
C88 S1#18pin@363_polysilicon-1 0 0.17fF
C89 S1#13pin@364_polysilicon-1 0 0.26fF
C90 S0#21pin@365_polysilicon-1 0 0.17fF
C91 S0#19pin@391_polysilicon-1 0 0.251fF
C92 S0#25pin@370_polysilicon-1 0 0.268fF
C93 net@1090#16pin@384_polysilicon-1 0 0.125fF
C94 S1#15pin@373_polysilicon-1 0 0.17fF
C95 S1#24pin@376_polysilicon-1 0 0.168fF
C96 net@1090#15pin@383_polysilicon-1 0 0.165fF
C97 S0#33pin@385_polysilicon-1 0 0.169fF
C98 net@1090#1pin@388_polysilicon-1 0 0.204fF
C99 S0#34pin@389_polysilicon-1 0 0.25fF
C100 net@1090 0 0.251fF
C101 net@1090#4pin@393_polysilicon-1 0 0.24fF
C102 net@1111#1pin@397_polysilicon-1 0 0.153fF
C103 net@1111#3pin@398_polysilicon-1 0 0.156fF
C104 net@1111#6pin@400_polysilicon-1 0 0.194fF
C105 S1#14pin@401_polysilicon-1 0 0.168fF
C106 S1#51pin@421_polysilicon-1 0 0.17fF
C107 S1#47pin@422_polysilicon-1 0 0.26fF
C108 S0#50pin@423_polysilicon-1 0 0.17fF
C109 S0#42pin@424_polysilicon-1 0 0.251fF
C110 S0#39pin@428_polysilicon-1 0 0.268fF
C111 net@1276#9pin@442_polysilicon-1 0 0.125fF
C112 S1#28pin@431_polysilicon-1 0 0.17fF
C113 S1#32pin@434_polysilicon-1 0 0.168fF
C114 net@1276#8pin@441_polysilicon-1 0 0.165fF
C115 S0#47pin@443_polysilicon-1 0 0.169fF
C116 net@1276#11pin@446_polysilicon-1 0 0.204fF
C117 S0#48pin@447_polysilicon-1 0 0.25fF
C118 net@1276#13pin@450_polysilicon-1 0 0.251fF
C119 net@1276#16pin@451_polysilicon-1 0 0.24fF
C120 net@1271#7pin@455_polysilicon-1 0 0.153fF
C121 net@1271#9pin@456_polysilicon-1 0 0.156fF
C122 net@1271#11pin@458_polysilicon-1 0 0.194fF
C123 S1#48pin@459_polysilicon-1 0 0.168fF
C124 S1#39pin@479_polysilicon-1 0 0.17fF
C125 S1#34pin@480_polysilicon-1 0 0.26fF
C126 S0#55pin@481_polysilicon-1 0 0.17fF
C127 S0#53pin@507_polysilicon-1 0 0.251fF
C128 S0#59pin@486_polysilicon-1 0 0.266fF
C129 net@1360#16pin@500_polysilicon-1 0 0.125fF
C130 S1#36pin@489_polysilicon-1 0 0.17fF
C131 S1#45pin@492_polysilicon-1 0 0.168fF
C132 net@1360#15pin@499_polysilicon-1 0 0.165fF
C133 S0#67pin@501_polysilicon-1 0 0.169fF
C134 net@1360#1pin@504_polysilicon-1 0 0.204fF
C135 S0#68pin@505_polysilicon-1 0 0.25fF
C136 net@1360 0 0.251fF
C137 net@1360#4pin@509_polysilicon-1 0 0.24fF
C138 net@1381#1pin@513_polysilicon-1 0 0.153fF
C139 net@1381#3pin@514_polysilicon-1 0 0.156fF
C140 net@1381#6pin@516_polysilicon-1 0 0.194fF
C141 S1#35pin@517_polysilicon-1 0 0.168fF
C142 S3#12pin@537_polysilicon-1 0 0.17fF
C143 S3#8pin@538_polysilicon-1 0 0.26fF
C144 S2#14pin@539_polysilicon-1 0 0.17fF
C145 S2#6pin@540_polysilicon-1 0 0.251fF
C146 S2#3pin@544_polysilicon-1 0 0.267fF
C147 net@1644#9pin@558_polysilicon-1 0 0.125fF
C148 S3#2pin@547_polysilicon-1 0 0.17fF
C149 S3#6pin@550_polysilicon-1 0 0.168fF
C150 net@1644#8pin@557_polysilicon-1 0 0.165fF
C151 S2#11pin@559_polysilicon-1 0 0.169fF
C152 net@1644#11pin@562_polysilicon-1 0 0.204fF
C153 S2#12pin@563_polysilicon-1 0 0.25fF
C154 net@1644#13pin@566_polysilicon-1 0 0.251fF
C155 net@1644#16pin@567_polysilicon-1 0 0.24fF
C156 net@1637#8pin@571_polysilicon-1 0 0.153fF
C157 net@1637#10pin@572_polysilicon-1 0 0.156fF
C158 net@1637#12pin@574_polysilicon-1 0 0.194fF
C159 S3#9pin@575_polysilicon-1 0 0.168fF
C160 S2#18pin@592_metal-1 0 11.392fF
C161 S3#13pin@594_metal-1 0 11.641fF
** Extracted Parasitic Resistors ***
R0 S0#0nmos@41_poly-left S0#0nmos@41_poly-left##0 9.688
R1 S0#0nmos@41_poly-left##0 S0#0nmos@41_poly-left##1 9.688
R2 S0#0nmos@41_poly-left##1 S0#0nmos@41_poly-left##2 9.688
R3 S0#0nmos@41_poly-left##2 S0#1pin@333_polysilicon-1 9.688
R4 net@909 net@909##0 9.858
R5 net@909##0 net@909##1 9.858
R6 net@909##1 net@909##2 9.858
R7 net@909##2 net@909##3 9.858
R8 net@909##3 net@909##4 9.858
R9 net@909##4 net@909##5 9.858
R10 net@909##5 net@909##6 9.858
R11 net@909##6 net@909##7 9.858
R12 net@909##7 net@909##8 9.858
R13 net@909##8 net@909##9 9.858
R14 net@909##9 net@909##10 9.858
R15 net@909##10 net@909##11 9.858
R16 net@909##11 net@909##12 9.858
R17 net@909##12 net@909##13 9.858
R18 net@909##13 net@909##14 9.858
R19 net@909##14 net@909##15 9.858
R20 net@909##15 net@909##16 9.858
R21 net@909##16 net@909##17 9.858
R22 net@909##17 net@909##18 9.858
R23 net@909##18 net@909##19 9.858
R24 net@909##19 net@909##20 9.858
R25 net@909##20 net@909##21 9.858
R26 net@909##21 net@909##22 9.858
R27 net@909##22 net@909##23 9.858
R28 net@909##23 net@909#1pin@330_polysilicon-1 9.858
R29 net@909#2pmos@41_poly-left net@909#2pmos@41_poly-left##0 9.688
R30 net@909#2pmos@41_poly-left##0 net@909#2pmos@41_poly-left##1 9.688
R31 net@909#2pmos@41_poly-left##1 net@909#2pmos@41_poly-left##2 9.688
R32 net@909#2pmos@41_poly-left##2 net@909 9.688
R33 net@909#3nmos@40_poly-left net@909#3nmos@40_poly-left##0 9.688
R34 net@909#3nmos@40_poly-left##0 net@909#3nmos@40_poly-left##1 9.688
R35 net@909#3nmos@40_poly-left##1 net@909#3nmos@40_poly-left##2 9.688
R36 net@909#3nmos@40_poly-left##2 net@909#4pin@335_polysilicon-1 9.688
R37 net@909 net@909##0 9.743
R38 net@909##0 net@909##1 9.743
R39 net@909##1 net@909##2 9.743
R40 net@909##2 net@909##3 9.743
R41 net@909##3 net@909##4 9.743
R42 net@909##4 net@909##5 9.743
R43 net@909##5 net@909#4pin@335_polysilicon-1 9.743
R44 net@909#5contact@366_metal-1-metal-2 net@909#5contact@366_metal-1-metal-2##0 9.3
R45 net@909#5contact@366_metal-1-metal-2##0 net@909#5contact@366_metal-1-metal-2##1 9.3
R46 net@909#5contact@366_metal-1-metal-2##1 net@909#5contact@366_metal-1-metal-2##2 9.3
R47 net@909#5contact@366_metal-1-metal-2##2 net@909#5contact@366_metal-1-metal-2##3 9.3
R48 net@909#5contact@366_metal-1-metal-2##3 net@909#5contact@366_metal-1-metal-2##4 9.3
R49 net@909#5contact@366_metal-1-metal-2##4 net@909#5contact@366_metal-1-metal-2##5 9.3
R50 net@909#5contact@366_metal-1-metal-2##5 net@909#5contact@366_metal-1-metal-2##6 9.3
R51 net@909#5contact@366_metal-1-metal-2##6 net@909#4pin@335_polysilicon-1 9.3
R52 net@930 net@930##0 9.688
R53 net@930##0 net@930##1 9.688
R54 net@930##1 net@930##2 9.688
R55 net@930##2 net@930#1pin@339_polysilicon-1 9.688
R56 net@931 net@931 0
R57 net@930#2pmos@45_poly-left net@930#2pmos@45_poly-left##0 9.688
R58 net@930#2pmos@45_poly-left##0 net@930#2pmos@45_poly-left##1 9.688
R59 net@930#2pmos@45_poly-left##1 net@930#2pmos@45_poly-left##2 9.688
R60 net@930#2pmos@45_poly-left##2 net@930#3pin@340_polysilicon-1 9.688
R61 net@930#3pin@340_polysilicon-1 net@930#3pin@340_polysilicon-1##0 9.92
R62 net@930#3pin@340_polysilicon-1##0 net@930#3pin@340_polysilicon-1##1 9.92
R63 net@930#3pin@340_polysilicon-1##1 net@930#3pin@340_polysilicon-1##2 9.92
R64 net@930#3pin@340_polysilicon-1##2 net@930#3pin@340_polysilicon-1##3 9.92
R65 net@930#3pin@340_polysilicon-1##3 net@930#6pin@342_polysilicon-1 9.92
R66 net@930#6pin@342_polysilicon-1 net@930#6pin@342_polysilicon-1##0 9.3
R67 net@930#6pin@342_polysilicon-1##0 net@930#6pin@342_polysilicon-1##1 9.3
R68 net@930#6pin@342_polysilicon-1##1 net@930#6pin@342_polysilicon-1##2 9.3
R69 net@930#6pin@342_polysilicon-1##2 net@930#6pin@342_polysilicon-1##3 9.3
R70 net@930#6pin@342_polysilicon-1##3 net@930#6pin@342_polysilicon-1##4 9.3
R71 net@930#6pin@342_polysilicon-1##4 net@930#1pin@339_polysilicon-1 9.3
R72 net@930#4contact@368_metal-1-metal-2 net@930#4contact@368_metal-1-metal-2##0 5.425
R73 net@930#4contact@368_metal-1-metal-2##0 net@930#6pin@342_polysilicon-1 5.425
R74 S1#0pin@306_polysilicon-1 S1#0pin@306_polysilicon-1##0 9.652
R75 S1#0pin@306_polysilicon-1##0 S1#0pin@306_polysilicon-1##1 9.652
R76 S1#0pin@306_polysilicon-1##1 S1#0pin@306_polysilicon-1##2 9.652
R77 S1#0pin@306_polysilicon-1##2 S1#0pin@306_polysilicon-1##3 9.652
R78 S1#0pin@306_polysilicon-1##3 S1#0pin@306_polysilicon-1##4 9.652
R79 S1#0pin@306_polysilicon-1##4 S1#0pin@306_polysilicon-1##5 9.652
R80 S1#0pin@306_polysilicon-1##5 S1#0pin@306_polysilicon-1##6 9.652
R81 S1#0pin@306_polysilicon-1##6 S1#0pin@306_polysilicon-1##7 9.652
R82 S1#0pin@306_polysilicon-1##7 S1#0pin@306_polysilicon-1##8 9.652
R83 S1#0pin@306_polysilicon-1##8 S1#0pin@306_polysilicon-1##9 9.652
R84 S1#0pin@306_polysilicon-1##9 S1#0pin@306_polysilicon-1##10 9.652
R85 S1#0pin@306_polysilicon-1##10 S1#0pin@306_polysilicon-1##11 9.652
R86 S1#0pin@306_polysilicon-1##11 S1#0pin@306_polysilicon-1##12 9.652
R87 S1#0pin@306_polysilicon-1##12 S1#0pin@306_polysilicon-1##13 9.652
R88 S1#0pin@306_polysilicon-1##13 S1#0pin@306_polysilicon-1##14 9.652
R89 S1#0pin@306_polysilicon-1##14 S1#0pin@306_polysilicon-1##15 9.652
R90 S1#0pin@306_polysilicon-1##15 S1#0pin@306_polysilicon-1##16 9.652
R91 S1#0pin@306_polysilicon-1##16 S1#0pin@306_polysilicon-1##17 9.652
R92 S1#0pin@306_polysilicon-1##17 S1#0pin@306_polysilicon-1##18 9.652
R93 S1#0pin@306_polysilicon-1##18 S1#0pin@306_polysilicon-1##19 9.652
R94 S1#0pin@306_polysilicon-1##19 S1#0pin@306_polysilicon-1##20 9.652
R95 S1#0pin@306_polysilicon-1##20 S1#1pin@343_polysilicon-1 9.652
R96 S1#2pin@315_polysilicon-1 S1#2pin@315_polysilicon-1##0 9.61
R97 S1#2pin@315_polysilicon-1##0 S1#2pin@315_polysilicon-1##1 9.61
R98 S1#2pin@315_polysilicon-1##1 S1#2pin@315_polysilicon-1##2 9.61
R99 S1#2pin@315_polysilicon-1##2 S1#2pin@315_polysilicon-1##3 9.61
R100 S1#2pin@315_polysilicon-1##3 S1#1pin@343_polysilicon-1 9.61
R101 S1#3nmos@45_poly-left S1#3nmos@45_poly-left##0 9.688
R102 S1#3nmos@45_poly-left##0 S1#3nmos@45_poly-left##1 9.688
R103 S1#3nmos@45_poly-left##1 S1#3nmos@45_poly-left##2 9.688
R104 S1#3nmos@45_poly-left##2 S1#0pin@306_polysilicon-1 9.688
R105 net@962 net@962 0
R106 net@962 net@962 0
R107 S1#4pmos@44_poly-left S1#4pmos@44_poly-left##0 9.688
R108 S1#4pmos@44_poly-left##0 S1#4pmos@44_poly-left##1 9.688
R109 S1#4pmos@44_poly-left##1 S1#4pmos@44_poly-left##2 9.688
R110 S1#4pmos@44_poly-left##2 S1#5pin@305_polysilicon-1 9.688
R111 S1#5pin@305_polysilicon-1 S1#5pin@305_polysilicon-1##0 9.958
R112 S1#5pin@305_polysilicon-1##0 S1#5pin@305_polysilicon-1##1 9.958
R113 S1#5pin@305_polysilicon-1##1 S1#5pin@305_polysilicon-1##2 9.958
R114 S1#5pin@305_polysilicon-1##2 S1#5pin@305_polysilicon-1##3 9.958
R115 S1#5pin@305_polysilicon-1##3 S1#5pin@305_polysilicon-1##4 9.958
R116 S1#5pin@305_polysilicon-1##4 S1#5pin@305_polysilicon-1##5 9.958
R117 S1#5pin@305_polysilicon-1##5 S1#5pin@305_polysilicon-1##6 9.958
R118 S1#5pin@305_polysilicon-1##6 S1#5pin@305_polysilicon-1##7 9.958
R119 S1#5pin@305_polysilicon-1##7 S1#5pin@305_polysilicon-1##8 9.958
R120 S1#5pin@305_polysilicon-1##8 S1#5pin@305_polysilicon-1##9 9.958
R121 S1#5pin@305_polysilicon-1##9 S1#5pin@305_polysilicon-1##10 9.958
R122 S1#5pin@305_polysilicon-1##10 S1#5pin@305_polysilicon-1##11 9.958
R123 S1#5pin@305_polysilicon-1##11 S1#5pin@305_polysilicon-1##12 9.958
R124 S1#5pin@305_polysilicon-1##12 S1#5pin@305_polysilicon-1##13 9.958
R125 S1#5pin@305_polysilicon-1##13 S1#5pin@305_polysilicon-1##14 9.958
R126 S1#5pin@305_polysilicon-1##14 S1#5pin@305_polysilicon-1##15 9.958
R127 S1#5pin@305_polysilicon-1##15 S1#5pin@305_polysilicon-1##16 9.958
R128 S1#5pin@305_polysilicon-1##16 S1#5pin@305_polysilicon-1##17 9.958
R129 S1#5pin@305_polysilicon-1##17 S1#5pin@305_polysilicon-1##18 9.958
R130 S1#5pin@305_polysilicon-1##18 S1#5pin@305_polysilicon-1##19 9.958
R131 S1#5pin@305_polysilicon-1##19 S1#5pin@305_polysilicon-1##20 9.958
R132 S1#5pin@305_polysilicon-1##20 S1#5pin@305_polysilicon-1##21 9.958
R133 S1#5pin@305_polysilicon-1##21 S1#5pin@305_polysilicon-1##22 9.958
R134 S1#5pin@305_polysilicon-1##22 S1#5pin@305_polysilicon-1##23 9.958
R135 S1#5pin@305_polysilicon-1##23 S1#5pin@305_polysilicon-1##24 9.958
R136 S1#5pin@305_polysilicon-1##24 S1#5pin@305_polysilicon-1##25 9.958
R137 S1#5pin@305_polysilicon-1##25 S1#5pin@305_polysilicon-1##26 9.958
R138 S1#5pin@305_polysilicon-1##26 S1#5pin@305_polysilicon-1##27 9.958
R139 S1#5pin@305_polysilicon-1##27 S1#5pin@305_polysilicon-1##28 9.958
R140 S1#5pin@305_polysilicon-1##28 S1#5pin@305_polysilicon-1##29 9.958
R141 S1#5pin@305_polysilicon-1##29 S1#5pin@305_polysilicon-1##30 9.958
R142 S1#5pin@305_polysilicon-1##30 S1#5pin@305_polysilicon-1##31 9.958
R143 S1#5pin@305_polysilicon-1##31 S1#0pin@306_polysilicon-1 9.958
R144 S0#2pmos@40_poly-left S0#2pmos@40_poly-left##0 9.688
R145 S0#2pmos@40_poly-left##0 S0#2pmos@40_poly-left##1 9.688
R146 S0#2pmos@40_poly-left##1 S0#2pmos@40_poly-left##2 9.688
R147 S0#2pmos@40_poly-left##2 S0#3pin@307_polysilicon-1 9.688
R148 net@963 net@963 0
R149 net@930#4contact@368_metal-1-metal-2 net@930#4contact@368_metal-1-metal-2 0
R150 net@909#10contact@360_metal-1-n-act net@909#10contact@360_metal-1-n-act 0
R151 S0#6pmos@47_poly-right S0#6pmos@47_poly-right##0 9.937
R152 S0#6pmos@47_poly-right##0 S0#6pmos@47_poly-right##1 9.937
R153 S0#6pmos@47_poly-right##1 S0#6pmos@47_poly-right##2 9.937
R154 S0#6pmos@47_poly-right##2 S0#6pmos@47_poly-right##3 9.937
R155 S0#6pmos@47_poly-right##3 S0#6pmos@47_poly-right##4 9.937
R156 S0#6pmos@47_poly-right##4 S0#6pmos@47_poly-right##5 9.937
R157 S0#6pmos@47_poly-right##5 S0#6pmos@47_poly-right##6 9.937
R158 S0#6pmos@47_poly-right##6 S0#6pmos@47_poly-right##7 9.937
R159 S0#6pmos@47_poly-right##7 S0#6pmos@47_poly-right##8 9.937
R160 S0#6pmos@47_poly-right##8 S0#6pmos@47_poly-right##9 9.937
R161 S0#6pmos@47_poly-right##9 S0#6pmos@47_poly-right##10 9.937
R162 S0#6pmos@47_poly-right##10 S0#6pmos@47_poly-right##11 9.937
R163 S0#6pmos@47_poly-right##11 S0#6pmos@47_poly-right##12 9.937
R164 S0#6pmos@47_poly-right##12 S0#6pmos@47_poly-right##13 9.937
R165 S0#6pmos@47_poly-right##13 S0#6pmos@47_poly-right##14 9.937
R166 S0#6pmos@47_poly-right##14 S0#6pmos@47_poly-right##15 9.937
R167 S0#6pmos@47_poly-right##15 S0#6pmos@47_poly-right##16 9.937
R168 S0#6pmos@47_poly-right##16 S0#6pmos@47_poly-right##17 9.937
R169 S0#6pmos@47_poly-right##17 S0#6pmos@47_poly-right##18 9.937
R170 S0#6pmos@47_poly-right##18 S0#6pmos@47_poly-right##19 9.937
R171 S0#6pmos@47_poly-right##19 S0#6pmos@47_poly-right##20 9.937
R172 S0#6pmos@47_poly-right##20 S0#6pmos@47_poly-right##21 9.937
R173 S0#6pmos@47_poly-right##21 S0#6pmos@47_poly-right##22 9.937
R174 S0#6pmos@47_poly-right##22 S0#6pmos@47_poly-right##23 9.937
R175 S0#6pmos@47_poly-right##23 S0#6pmos@47_poly-right##24 9.937
R176 S0#6pmos@47_poly-right##24 S0#6pmos@47_poly-right##25 9.937
R177 S0#6pmos@47_poly-right##25 S0#6pmos@47_poly-right##26 9.937
R178 S0#6pmos@47_poly-right##26 S0#6pmos@47_poly-right##27 9.937
R179 S0#6pmos@47_poly-right##27 S0#6pmos@47_poly-right##28 9.937
R180 S0#6pmos@47_poly-right##28 S0#6pmos@47_poly-right##29 9.937
R181 S0#6pmos@47_poly-right##29 S0#6pmos@47_poly-right##30 9.937
R182 S0#6pmos@47_poly-right##30 S0#6pmos@47_poly-right##31 9.937
R183 S0#6pmos@47_poly-right##31 S0#6pmos@47_poly-right##32 9.937
R184 S0#6pmos@47_poly-right##32 S0#6pmos@47_poly-right##33 9.937
R185 S0#6pmos@47_poly-right##33 S0#6pmos@47_poly-right##34 9.937
R186 S0#6pmos@47_poly-right##34 S0#6pmos@47_poly-right##35 9.937
R187 S0#6pmos@47_poly-right##35 S0#6pmos@47_poly-right##36 9.937
R188 S0#6pmos@47_poly-right##36 S0#6pmos@47_poly-right##37 9.937
R189 S0#6pmos@47_poly-right##37 S0#6pmos@47_poly-right##38 9.937
R190 S0#6pmos@47_poly-right##38 S0#6pmos@47_poly-right##39 9.937
R191 S0#6pmos@47_poly-right##39 S0#6pmos@47_poly-right##40 9.937
R192 S0#6pmos@47_poly-right##40 S0#6pmos@47_poly-right##41 9.937
R193 S0#6pmos@47_poly-right##41 S0#6pmos@47_poly-right##42 9.937
R194 S0#6pmos@47_poly-right##42 S0#6pmos@47_poly-right##43 9.937
R195 S0#6pmos@47_poly-right##43 S0#6pmos@47_poly-right##44 9.937
R196 S0#6pmos@47_poly-right##44 S0#6pmos@47_poly-right##45 9.937
R197 S0#6pmos@47_poly-right##45 S0#6pmos@47_poly-right##46 9.937
R198 S0#6pmos@47_poly-right##46 S0#6pmos@47_poly-right##47 9.937
R199 S0#6pmos@47_poly-right##47 S0#6pmos@47_poly-right##48 9.937
R200 S0#6pmos@47_poly-right##48 S0#6pmos@47_poly-right##49 9.937
R201 S0#6pmos@47_poly-right##49 S0#6pmos@47_poly-right##50 9.937
R202 S0#6pmos@47_poly-right##50 S0#6pmos@47_poly-right##51 9.937
R203 S0#6pmos@47_poly-right##51 S0#6pmos@47_poly-right##52 9.937
R204 S0#6pmos@47_poly-right##52 S0#6pmos@47_poly-right##53 9.937
R205 S0#6pmos@47_poly-right##53 S0#6pmos@47_poly-right##54 9.937
R206 S0#6pmos@47_poly-right##54 S0#7pin@312_polysilicon-1 9.937
R207 S0#7pin@312_polysilicon-1 S0#7pin@312_polysilicon-1##0 9.688
R208 S0#7pin@312_polysilicon-1##0 S0#7pin@312_polysilicon-1##1 9.688
R209 S0#7pin@312_polysilicon-1##1 S0#7pin@312_polysilicon-1##2 9.688
R210 S0#7pin@312_polysilicon-1##2 S0#7pin@312_polysilicon-1##3 9.688
R211 S0#7pin@312_polysilicon-1##3 S0#7pin@312_polysilicon-1##4 9.688
R212 S0#7pin@312_polysilicon-1##4 S0#7pin@312_polysilicon-1##5 9.688
R213 S0#7pin@312_polysilicon-1##5 S0#7pin@312_polysilicon-1##6 9.688
R214 S0#7pin@312_polysilicon-1##6 S0#8nmos@47_poly-right 9.688
R215 net@963 net@963 0
R216 S0#4contact@362_metal-1-metal-2 S0#4contact@362_metal-1-metal-2##0 9.582
R217 S0#4contact@362_metal-1-metal-2##0 S0#4contact@362_metal-1-metal-2##1 9.582
R218 S0#4contact@362_metal-1-metal-2##1 S0#4contact@362_metal-1-metal-2##2 9.582
R219 S0#4contact@362_metal-1-metal-2##2 S0#4contact@362_metal-1-metal-2##3 9.582
R220 S0#4contact@362_metal-1-metal-2##3 S0#4contact@362_metal-1-metal-2##4 9.582
R221 S0#4contact@362_metal-1-metal-2##4 S0#4contact@362_metal-1-metal-2##5 9.582
R222 S0#4contact@362_metal-1-metal-2##5 S0#4contact@362_metal-1-metal-2##6 9.582
R223 S0#4contact@362_metal-1-metal-2##6 S0#4contact@362_metal-1-metal-2##7 9.582
R224 S0#4contact@362_metal-1-metal-2##7 S0#4contact@362_metal-1-metal-2##8 9.582
R225 S0#4contact@362_metal-1-metal-2##8 S0#4contact@362_metal-1-metal-2##9 9.582
R226 S0#4contact@362_metal-1-metal-2##9 S0#7pin@312_polysilicon-1 9.582
R227 net@909#5contact@366_metal-1-metal-2 net@909#10contact@360_metal-1-n-act 4.927
R228 S1#2pin@315_polysilicon-1 S1#2pin@315_polysilicon-1##0 9.688
R229 S1#2pin@315_polysilicon-1##0 S1#2pin@315_polysilicon-1##1 9.688
R230 S1#2pin@315_polysilicon-1##1 S1#2pin@315_polysilicon-1##2 9.688
R231 S1#2pin@315_polysilicon-1##2 S1#2pin@315_polysilicon-1##3 9.688
R232 S1#2pin@315_polysilicon-1##3 S1#2pin@315_polysilicon-1##4 9.688
R233 S1#2pin@315_polysilicon-1##4 S1#2pin@315_polysilicon-1##5 9.688
R234 S1#2pin@315_polysilicon-1##5 S1#2pin@315_polysilicon-1##6 9.688
R235 S1#2pin@315_polysilicon-1##6 S1#2pin@315_polysilicon-1##7 9.688
R236 S1#2pin@315_polysilicon-1##7 S1#2pin@315_polysilicon-1##8 9.688
R237 S1#2pin@315_polysilicon-1##8 S1#2pin@315_polysilicon-1##9 9.688
R238 S1#2pin@315_polysilicon-1##9 S1#2pin@315_polysilicon-1##10 9.688
R239 S1#2pin@315_polysilicon-1##10 S1#2pin@315_polysilicon-1##11 9.688
R240 S1#2pin@315_polysilicon-1##11 S1#2pin@315_polysilicon-1##12 9.688
R241 S1#2pin@315_polysilicon-1##12 S1#2pin@315_polysilicon-1##13 9.688
R242 S1#2pin@315_polysilicon-1##13 S1#2pin@315_polysilicon-1##14 9.688
R243 S1#2pin@315_polysilicon-1##14 S1#2pin@315_polysilicon-1##15 9.688
R244 S1#2pin@315_polysilicon-1##15 S1#2pin@315_polysilicon-1##16 9.688
R245 S1#2pin@315_polysilicon-1##16 S1#2pin@315_polysilicon-1##17 9.688
R246 S1#2pin@315_polysilicon-1##17 S1#2pin@315_polysilicon-1##18 9.688
R247 S1#2pin@315_polysilicon-1##18 S1#2pin@315_polysilicon-1##19 9.688
R248 S1#2pin@315_polysilicon-1##19 S1#2pin@315_polysilicon-1##20 9.688
R249 S1#2pin@315_polysilicon-1##20 S1#2pin@315_polysilicon-1##21 9.688
R250 S1#2pin@315_polysilicon-1##21 S1#2pin@315_polysilicon-1##22 9.688
R251 S1#2pin@315_polysilicon-1##22 S1#2pin@315_polysilicon-1##23 9.688
R252 S1#2pin@315_polysilicon-1##23 S1#2pin@315_polysilicon-1##24 9.688
R253 S1#2pin@315_polysilicon-1##24 S1#2pin@315_polysilicon-1##25 9.688
R254 S1#2pin@315_polysilicon-1##25 S1#2pin@315_polysilicon-1##26 9.688
R255 S1#2pin@315_polysilicon-1##26 S1#6pin@316_polysilicon-1 9.688
R256 S1#10pmos@46_poly-right S1#10pmos@46_poly-right##0 9.89
R257 S1#10pmos@46_poly-right##0 S1#10pmos@46_poly-right##1 9.89
R258 S1#10pmos@46_poly-right##1 S1#10pmos@46_poly-right##2 9.89
R259 S1#10pmos@46_poly-right##2 S1#10pmos@46_poly-right##3 9.89
R260 S1#10pmos@46_poly-right##3 S1#10pmos@46_poly-right##4 9.89
R261 S1#10pmos@46_poly-right##4 S1#10pmos@46_poly-right##5 9.89
R262 S1#10pmos@46_poly-right##5 S1#10pmos@46_poly-right##6 9.89
R263 S1#10pmos@46_poly-right##6 S1#10pmos@46_poly-right##7 9.89
R264 S1#10pmos@46_poly-right##7 S1#10pmos@46_poly-right##8 9.89
R265 S1#10pmos@46_poly-right##8 S1#10pmos@46_poly-right##9 9.89
R266 S1#10pmos@46_poly-right##9 S1#10pmos@46_poly-right##10 9.89
R267 S1#10pmos@46_poly-right##10 S1#10pmos@46_poly-right##11 9.89
R268 S1#10pmos@46_poly-right##11 S1#10pmos@46_poly-right##12 9.89
R269 S1#10pmos@46_poly-right##12 S1#10pmos@46_poly-right##13 9.89
R270 S1#10pmos@46_poly-right##13 S1#10pmos@46_poly-right##14 9.89
R271 S1#10pmos@46_poly-right##14 S1#10pmos@46_poly-right##15 9.89
R272 S1#10pmos@46_poly-right##15 S1#10pmos@46_poly-right##16 9.89
R273 S1#10pmos@46_poly-right##16 S1#10pmos@46_poly-right##17 9.89
R274 S1#10pmos@46_poly-right##17 S1#10pmos@46_poly-right##18 9.89
R275 S1#10pmos@46_poly-right##18 S1#10pmos@46_poly-right##19 9.89
R276 S1#10pmos@46_poly-right##19 S1#10pmos@46_poly-right##20 9.89
R277 S1#10pmos@46_poly-right##20 S1#10pmos@46_poly-right##21 9.89
R278 S1#10pmos@46_poly-right##21 S1#10pmos@46_poly-right##22 9.89
R279 S1#10pmos@46_poly-right##22 S1#10pmos@46_poly-right##23 9.89
R280 S1#10pmos@46_poly-right##23 S1#10pmos@46_poly-right##24 9.89
R281 S1#10pmos@46_poly-right##24 S1#10pmos@46_poly-right##25 9.89
R282 S1#10pmos@46_poly-right##25 S1#10pmos@46_poly-right##26 9.89
R283 S1#10pmos@46_poly-right##26 S1#10pmos@46_poly-right##27 9.89
R284 S1#10pmos@46_poly-right##27 S1#10pmos@46_poly-right##28 9.89
R285 S1#10pmos@46_poly-right##28 S1#10pmos@46_poly-right##29 9.89
R286 S1#10pmos@46_poly-right##29 S1#10pmos@46_poly-right##30 9.89
R287 S1#10pmos@46_poly-right##30 S1#10pmos@46_poly-right##31 9.89
R288 S1#10pmos@46_poly-right##31 S1#10pmos@46_poly-right##32 9.89
R289 S1#10pmos@46_poly-right##32 S1#10pmos@46_poly-right##33 9.89
R290 S1#10pmos@46_poly-right##33 S1#10pmos@46_poly-right##34 9.89
R291 S1#10pmos@46_poly-right##34 S1#10pmos@46_poly-right##35 9.89
R292 S1#10pmos@46_poly-right##35 S1#10pmos@46_poly-right##36 9.89
R293 S1#10pmos@46_poly-right##36 S1#10pmos@46_poly-right##37 9.89
R294 S1#10pmos@46_poly-right##37 S1#10pmos@46_poly-right##38 9.89
R295 S1#10pmos@46_poly-right##38 S1#10pmos@46_poly-right##39 9.89
R296 S1#10pmos@46_poly-right##39 S1#10pmos@46_poly-right##40 9.89
R297 S1#10pmos@46_poly-right##40 S1#10pmos@46_poly-right##41 9.89
R298 S1#10pmos@46_poly-right##41 S1#10pmos@46_poly-right##42 9.89
R299 S1#10pmos@46_poly-right##42 S1#10pmos@46_poly-right##43 9.89
R300 S1#10pmos@46_poly-right##43 S1#10pmos@46_poly-right##44 9.89
R301 S1#10pmos@46_poly-right##44 S1#10pmos@46_poly-right##45 9.89
R302 S1#10pmos@46_poly-right##45 S1#10pmos@46_poly-right##46 9.89
R303 S1#10pmos@46_poly-right##46 S1#10pmos@46_poly-right##47 9.89
R304 S1#10pmos@46_poly-right##47 S1#10pmos@46_poly-right##48 9.89
R305 S1#10pmos@46_poly-right##48 S1#10pmos@46_poly-right##49 9.89
R306 S1#10pmos@46_poly-right##49 S1#10pmos@46_poly-right##50 9.89
R307 S1#10pmos@46_poly-right##50 S1#10pmos@46_poly-right##51 9.89
R308 S1#10pmos@46_poly-right##51 S1#10pmos@46_poly-right##52 9.89
R309 S1#10pmos@46_poly-right##52 S1#10pmos@46_poly-right##53 9.89
R310 S1#10pmos@46_poly-right##53 S1#10pmos@46_poly-right##54 9.89
R311 S1#10pmos@46_poly-right##54 S1#10pmos@46_poly-right##55 9.89
R312 S1#10pmos@46_poly-right##55 S1#10pmos@46_poly-right##56 9.89
R313 S1#10pmos@46_poly-right##56 S1#10pmos@46_poly-right##57 9.89
R314 S1#10pmos@46_poly-right##57 S1#10pmos@46_poly-right##58 9.89
R315 S1#10pmos@46_poly-right##58 S1#10pmos@46_poly-right##59 9.89
R316 S1#10pmos@46_poly-right##59 S1#10pmos@46_poly-right##60 9.89
R317 S1#10pmos@46_poly-right##60 S1#10pmos@46_poly-right##61 9.89
R318 S1#10pmos@46_poly-right##61 S1#11pin@318_polysilicon-1 9.89
R319 S1#11pin@318_polysilicon-1 S1#6pin@316_polysilicon-1 7.75
R320 S1#8contact@372_metal-1-metal-2 S1#8contact@372_metal-1-metal-2##0 5.425
R321 S1#8contact@372_metal-1-metal-2##0 S1#11pin@318_polysilicon-1 5.425
R322 net@909#14pmos@43_poly-left net@909#14pmos@43_poly-left##0 9.688
R323 net@909#14pmos@43_poly-left##0 net@909#14pmos@43_poly-left##1 9.688
R324 net@909#14pmos@43_poly-left##1 net@909#14pmos@43_poly-left##2 9.688
R325 net@909#14pmos@43_poly-left##2 net@909#15pin@325_polysilicon-1 9.688
R326 net@909#15pin@325_polysilicon-1 net@909#15pin@325_polysilicon-1##0 9.946
R327 net@909#15pin@325_polysilicon-1##0 net@909#15pin@325_polysilicon-1##1 9.946
R328 net@909#15pin@325_polysilicon-1##1 net@909#15pin@325_polysilicon-1##2 9.946
R329 net@909#15pin@325_polysilicon-1##2 net@909#15pin@325_polysilicon-1##3 9.946
R330 net@909#15pin@325_polysilicon-1##3 net@909#15pin@325_polysilicon-1##4 9.946
R331 net@909#15pin@325_polysilicon-1##4 net@909#15pin@325_polysilicon-1##5 9.946
R332 net@909#15pin@325_polysilicon-1##5 net@909#15pin@325_polysilicon-1##6 9.946
R333 net@909#15pin@325_polysilicon-1##6 net@909#15pin@325_polysilicon-1##7 9.946
R334 net@909#15pin@325_polysilicon-1##7 net@909#15pin@325_polysilicon-1##8 9.946
R335 net@909#15pin@325_polysilicon-1##8 net@909#15pin@325_polysilicon-1##9 9.946
R336 net@909#15pin@325_polysilicon-1##9 net@909#15pin@325_polysilicon-1##10 9.946
R337 net@909#15pin@325_polysilicon-1##10 net@909#16pin@326_polysilicon-1 9.946
R338 S0#14nmos@43_poly-left S0#14nmos@43_poly-left##0 9.688
R339 S0#14nmos@43_poly-left##0 S0#14nmos@43_poly-left##1 9.688
R340 S0#14nmos@43_poly-left##1 S0#14nmos@43_poly-left##2 9.688
R341 S0#14nmos@43_poly-left##2 S0#15pin@327_polysilicon-1 9.688
R342 S0#4contact@362_metal-1-metal-2 S0#4contact@362_metal-1-metal-2##0 9.429
R343 S0#4contact@362_metal-1-metal-2##0 S0#4contact@362_metal-1-metal-2##1 9.429
R344 S0#4contact@362_metal-1-metal-2##1 S0#4contact@362_metal-1-metal-2##2 9.429
R345 S0#4contact@362_metal-1-metal-2##2 S0#4contact@362_metal-1-metal-2##3 9.429
R346 S0#4contact@362_metal-1-metal-2##3 S0#4contact@362_metal-1-metal-2##4 9.429
R347 S0#4contact@362_metal-1-metal-2##4 S0#4contact@362_metal-1-metal-2##5 9.429
R348 S0#4contact@362_metal-1-metal-2##5 S0#4contact@362_metal-1-metal-2##6 9.429
R349 S0#4contact@362_metal-1-metal-2##6 S0#4contact@362_metal-1-metal-2##7 9.429
R350 S0#4contact@362_metal-1-metal-2##7 S0#4contact@362_metal-1-metal-2##8 9.429
R351 S0#4contact@362_metal-1-metal-2##8 S0#4contact@362_metal-1-metal-2##9 9.429
R352 S0#4contact@362_metal-1-metal-2##9 S0#4contact@362_metal-1-metal-2##10 9.429
R353 S0#4contact@362_metal-1-metal-2##10 S0#14nmos@43_poly-left 9.429
R354 net@909#1pin@330_polysilicon-1 net@909#1pin@330_polysilicon-1##0 5.425
R355 net@909#1pin@330_polysilicon-1##0 net@909#16pin@326_polysilicon-1 5.425
R356 net@909#18nmos@42_poly-right net@909#18nmos@42_poly-right##0 9.688
R357 net@909#18nmos@42_poly-right##0 net@909#18nmos@42_poly-right##1 9.688
R358 net@909#18nmos@42_poly-right##1 net@909#18nmos@42_poly-right##2 9.688
R359 net@909#18nmos@42_poly-right##2 net@909#1pin@330_polysilicon-1 9.688
R360 S0#1pin@333_polysilicon-1 S0#1pin@333_polysilicon-1##0 9.521
R361 S0#1pin@333_polysilicon-1##0 S0#1pin@333_polysilicon-1##1 9.521
R362 S0#1pin@333_polysilicon-1##1 S0#1pin@333_polysilicon-1##2 9.521
R363 S0#1pin@333_polysilicon-1##2 S0#1pin@333_polysilicon-1##3 9.521
R364 S0#1pin@333_polysilicon-1##3 S0#1pin@333_polysilicon-1##4 9.521
R365 S0#1pin@333_polysilicon-1##4 S0#1pin@333_polysilicon-1##5 9.521
R366 S0#1pin@333_polysilicon-1##5 S0#16pin@331_polysilicon-1 9.521
R367 S0#16pin@331_polysilicon-1 S0#16pin@331_polysilicon-1##0 9.868
R368 S0#16pin@331_polysilicon-1##0 S0#16pin@331_polysilicon-1##1 9.868
R369 S0#16pin@331_polysilicon-1##1 S0#16pin@331_polysilicon-1##2 9.868
R370 S0#16pin@331_polysilicon-1##2 S0#16pin@331_polysilicon-1##3 9.868
R371 S0#16pin@331_polysilicon-1##3 S0#16pin@331_polysilicon-1##4 9.868
R372 S0#16pin@331_polysilicon-1##4 S0#16pin@331_polysilicon-1##5 9.868
R373 S0#16pin@331_polysilicon-1##5 S0#16pin@331_polysilicon-1##6 9.868
R374 S0#16pin@331_polysilicon-1##6 S0#16pin@331_polysilicon-1##7 9.868
R375 S0#16pin@331_polysilicon-1##7 S0#16pin@331_polysilicon-1##8 9.868
R376 S0#16pin@331_polysilicon-1##8 S0#16pin@331_polysilicon-1##9 9.868
R377 S0#16pin@331_polysilicon-1##9 S0#16pin@331_polysilicon-1##10 9.868
R378 S0#16pin@331_polysilicon-1##10 S0#16pin@331_polysilicon-1##11 9.868
R379 S0#16pin@331_polysilicon-1##11 S0#16pin@331_polysilicon-1##12 9.868
R380 S0#16pin@331_polysilicon-1##12 S0#16pin@331_polysilicon-1##13 9.868
R381 S0#16pin@331_polysilicon-1##13 S0#16pin@331_polysilicon-1##14 9.868
R382 S0#16pin@331_polysilicon-1##14 S0#16pin@331_polysilicon-1##15 9.868
R383 S0#16pin@331_polysilicon-1##15 S0#16pin@331_polysilicon-1##16 9.868
R384 S0#16pin@331_polysilicon-1##16 S0#16pin@331_polysilicon-1##17 9.868
R385 S0#16pin@331_polysilicon-1##17 S0#16pin@331_polysilicon-1##18 9.868
R386 S0#16pin@331_polysilicon-1##18 S0#16pin@331_polysilicon-1##19 9.868
R387 S0#16pin@331_polysilicon-1##19 S0#16pin@331_polysilicon-1##20 9.868
R388 S0#16pin@331_polysilicon-1##20 S0#16pin@331_polysilicon-1##21 9.868
R389 S0#16pin@331_polysilicon-1##21 S0#16pin@331_polysilicon-1##22 9.868
R390 S0#16pin@331_polysilicon-1##22 S0#16pin@331_polysilicon-1##23 9.868
R391 S0#16pin@331_polysilicon-1##23 S0#16pin@331_polysilicon-1##24 9.868
R392 S0#16pin@331_polysilicon-1##24 S0#16pin@331_polysilicon-1##25 9.868
R393 S0#16pin@331_polysilicon-1##25 S0#16pin@331_polysilicon-1##26 9.868
R394 S0#16pin@331_polysilicon-1##26 S0#16pin@331_polysilicon-1##27 9.868
R395 S0#16pin@331_polysilicon-1##27 S0#16pin@331_polysilicon-1##28 9.868
R396 S0#16pin@331_polysilicon-1##28 S0#15pin@327_polysilicon-1 9.868
R397 S0#17pmos@42_poly-left S0#17pmos@42_poly-left##0 9.688
R398 S0#17pmos@42_poly-left##0 S0#17pmos@42_poly-left##1 9.688
R399 S0#17pmos@42_poly-left##1 S0#17pmos@42_poly-left##2 9.688
R400 S0#17pmos@42_poly-left##2 S0#16pin@331_polysilicon-1 9.688
R401 net@931 net@931 0
R402 S0#3pin@307_polysilicon-1 S0#3pin@307_polysilicon-1##0 9.972
R403 S0#3pin@307_polysilicon-1##0 S0#3pin@307_polysilicon-1##1 9.972
R404 S0#3pin@307_polysilicon-1##1 S0#3pin@307_polysilicon-1##2 9.972
R405 S0#3pin@307_polysilicon-1##2 S0#3pin@307_polysilicon-1##3 9.972
R406 S0#3pin@307_polysilicon-1##3 S0#3pin@307_polysilicon-1##4 9.972
R407 S0#3pin@307_polysilicon-1##4 S0#3pin@307_polysilicon-1##5 9.972
R408 S0#3pin@307_polysilicon-1##5 S0#3pin@307_polysilicon-1##6 9.972
R409 S0#3pin@307_polysilicon-1##6 S0#3pin@307_polysilicon-1##7 9.972
R410 S0#3pin@307_polysilicon-1##7 S0#3pin@307_polysilicon-1##8 9.972
R411 S0#3pin@307_polysilicon-1##8 S0#3pin@307_polysilicon-1##9 9.972
R412 S0#3pin@307_polysilicon-1##9 S0#3pin@307_polysilicon-1##10 9.972
R413 S0#3pin@307_polysilicon-1##10 S0#3pin@307_polysilicon-1##11 9.972
R414 S0#3pin@307_polysilicon-1##11 S0#3pin@307_polysilicon-1##12 9.972
R415 S0#3pin@307_polysilicon-1##12 S0#3pin@307_polysilicon-1##13 9.972
R416 S0#3pin@307_polysilicon-1##13 S0#3pin@307_polysilicon-1##14 9.972
R417 S0#3pin@307_polysilicon-1##14 S0#3pin@307_polysilicon-1##15 9.972
R418 S0#3pin@307_polysilicon-1##15 S0#3pin@307_polysilicon-1##16 9.972
R419 S0#3pin@307_polysilicon-1##16 S0#3pin@307_polysilicon-1##17 9.972
R420 S0#3pin@307_polysilicon-1##17 S0#3pin@307_polysilicon-1##18 9.972
R421 S0#3pin@307_polysilicon-1##18 S0#3pin@307_polysilicon-1##19 9.972
R422 S0#3pin@307_polysilicon-1##19 S0#3pin@307_polysilicon-1##20 9.972
R423 S0#3pin@307_polysilicon-1##20 S0#3pin@307_polysilicon-1##21 9.972
R424 S0#3pin@307_polysilicon-1##21 S0#3pin@307_polysilicon-1##22 9.972
R425 S0#3pin@307_polysilicon-1##22 S0#3pin@307_polysilicon-1##23 9.972
R426 S0#3pin@307_polysilicon-1##23 S0#3pin@307_polysilicon-1##24 9.972
R427 S0#3pin@307_polysilicon-1##24 S0#3pin@307_polysilicon-1##25 9.972
R428 S0#3pin@307_polysilicon-1##25 S0#3pin@307_polysilicon-1##26 9.972
R429 S0#3pin@307_polysilicon-1##26 S0#3pin@307_polysilicon-1##27 9.972
R430 S0#3pin@307_polysilicon-1##27 S0#3pin@307_polysilicon-1##28 9.972
R431 S0#3pin@307_polysilicon-1##28 S0#1pin@333_polysilicon-1 9.972
R432 S0#18nmos@49_poly-left S0#18nmos@49_poly-left##0 9.688
R433 S0#18nmos@49_poly-left##0 S0#18nmos@49_poly-left##1 9.688
R434 S0#18nmos@49_poly-left##1 S0#18nmos@49_poly-left##2 9.688
R435 S0#18nmos@49_poly-left##2 S0#19pin@391_polysilicon-1 9.688
R436 net@1090 net@1090##0 9.858
R437 net@1090##0 net@1090##1 9.858
R438 net@1090##1 net@1090##2 9.858
R439 net@1090##2 net@1090##3 9.858
R440 net@1090##3 net@1090##4 9.858
R441 net@1090##4 net@1090##5 9.858
R442 net@1090##5 net@1090##6 9.858
R443 net@1090##6 net@1090##7 9.858
R444 net@1090##7 net@1090##8 9.858
R445 net@1090##8 net@1090##9 9.858
R446 net@1090##9 net@1090##10 9.858
R447 net@1090##10 net@1090##11 9.858
R448 net@1090##11 net@1090##12 9.858
R449 net@1090##12 net@1090##13 9.858
R450 net@1090##13 net@1090##14 9.858
R451 net@1090##14 net@1090##15 9.858
R452 net@1090##15 net@1090##16 9.858
R453 net@1090##16 net@1090##17 9.858
R454 net@1090##17 net@1090##18 9.858
R455 net@1090##18 net@1090##19 9.858
R456 net@1090##19 net@1090##20 9.858
R457 net@1090##20 net@1090##21 9.858
R458 net@1090##21 net@1090##22 9.858
R459 net@1090##22 net@1090##23 9.858
R460 net@1090##23 net@1090#1pin@388_polysilicon-1 9.858
R461 net@1090#2pmos@49_poly-left net@1090#2pmos@49_poly-left##0 9.688
R462 net@1090#2pmos@49_poly-left##0 net@1090#2pmos@49_poly-left##1 9.688
R463 net@1090#2pmos@49_poly-left##1 net@1090#2pmos@49_poly-left##2 9.688
R464 net@1090#2pmos@49_poly-left##2 net@1090 9.688
R465 net@1090#3nmos@48_poly-left net@1090#3nmos@48_poly-left##0 9.688
R466 net@1090#3nmos@48_poly-left##0 net@1090#3nmos@48_poly-left##1 9.688
R467 net@1090#3nmos@48_poly-left##1 net@1090#3nmos@48_poly-left##2 9.688
R468 net@1090#3nmos@48_poly-left##2 net@1090#4pin@393_polysilicon-1 9.688
R469 net@1090 net@1090##0 9.743
R470 net@1090##0 net@1090##1 9.743
R471 net@1090##1 net@1090##2 9.743
R472 net@1090##2 net@1090##3 9.743
R473 net@1090##3 net@1090##4 9.743
R474 net@1090##4 net@1090##5 9.743
R475 net@1090##5 net@1090#4pin@393_polysilicon-1 9.743
R476 net@1090#5contact@432_metal-1-metal-2 net@1090#5contact@432_metal-1-metal-2##0 9.3
R477 net@1090#5contact@432_metal-1-metal-2##0 net@1090#5contact@432_metal-1-metal-2##1 9.3
R478 net@1090#5contact@432_metal-1-metal-2##1 net@1090#5contact@432_metal-1-metal-2##2 9.3
R479 net@1090#5contact@432_metal-1-metal-2##2 net@1090#5contact@432_metal-1-metal-2##3 9.3
R480 net@1090#5contact@432_metal-1-metal-2##3 net@1090#5contact@432_metal-1-metal-2##4 9.3
R481 net@1090#5contact@432_metal-1-metal-2##4 net@1090#5contact@432_metal-1-metal-2##5 9.3
R482 net@1090#5contact@432_metal-1-metal-2##5 net@1090#5contact@432_metal-1-metal-2##6 9.3
R483 net@1090#5contact@432_metal-1-metal-2##6 net@1090#4pin@393_polysilicon-1 9.3
R484 net@1111 net@1111##0 9.688
R485 net@1111##0 net@1111##1 9.688
R486 net@1111##1 net@1111##2 9.688
R487 net@1111##2 net@1111#1pin@397_polysilicon-1 9.688
R488 net@1112 net@1112 0
R489 net@1111#2pmos@53_poly-left net@1111#2pmos@53_poly-left##0 9.688
R490 net@1111#2pmos@53_poly-left##0 net@1111#2pmos@53_poly-left##1 9.688
R491 net@1111#2pmos@53_poly-left##1 net@1111#2pmos@53_poly-left##2 9.688
R492 net@1111#2pmos@53_poly-left##2 net@1111#3pin@398_polysilicon-1 9.688
R493 net@1111#3pin@398_polysilicon-1 net@1111#3pin@398_polysilicon-1##0 9.92
R494 net@1111#3pin@398_polysilicon-1##0 net@1111#3pin@398_polysilicon-1##1 9.92
R495 net@1111#3pin@398_polysilicon-1##1 net@1111#3pin@398_polysilicon-1##2 9.92
R496 net@1111#3pin@398_polysilicon-1##2 net@1111#3pin@398_polysilicon-1##3 9.92
R497 net@1111#3pin@398_polysilicon-1##3 net@1111#6pin@400_polysilicon-1 9.92
R498 net@1111#6pin@400_polysilicon-1 net@1111#6pin@400_polysilicon-1##0 9.3
R499 net@1111#6pin@400_polysilicon-1##0 net@1111#6pin@400_polysilicon-1##1 9.3
R500 net@1111#6pin@400_polysilicon-1##1 net@1111#6pin@400_polysilicon-1##2 9.3
R501 net@1111#6pin@400_polysilicon-1##2 net@1111#6pin@400_polysilicon-1##3 9.3
R502 net@1111#6pin@400_polysilicon-1##3 net@1111#6pin@400_polysilicon-1##4 9.3
R503 net@1111#6pin@400_polysilicon-1##4 net@1111#1pin@397_polysilicon-1 9.3
R504 net@1111#4contact@434_metal-1-metal-2 net@1111#4contact@434_metal-1-metal-2##0 5.425
R505 net@1111#4contact@434_metal-1-metal-2##0 net@1111#6pin@400_polysilicon-1 5.425
R506 S1#13pin@364_polysilicon-1 S1#13pin@364_polysilicon-1##0 9.652
R507 S1#13pin@364_polysilicon-1##0 S1#13pin@364_polysilicon-1##1 9.652
R508 S1#13pin@364_polysilicon-1##1 S1#13pin@364_polysilicon-1##2 9.652
R509 S1#13pin@364_polysilicon-1##2 S1#13pin@364_polysilicon-1##3 9.652
R510 S1#13pin@364_polysilicon-1##3 S1#13pin@364_polysilicon-1##4 9.652
R511 S1#13pin@364_polysilicon-1##4 S1#13pin@364_polysilicon-1##5 9.652
R512 S1#13pin@364_polysilicon-1##5 S1#13pin@364_polysilicon-1##6 9.652
R513 S1#13pin@364_polysilicon-1##6 S1#13pin@364_polysilicon-1##7 9.652
R514 S1#13pin@364_polysilicon-1##7 S1#13pin@364_polysilicon-1##8 9.652
R515 S1#13pin@364_polysilicon-1##8 S1#13pin@364_polysilicon-1##9 9.652
R516 S1#13pin@364_polysilicon-1##9 S1#13pin@364_polysilicon-1##10 9.652
R517 S1#13pin@364_polysilicon-1##10 S1#13pin@364_polysilicon-1##11 9.652
R518 S1#13pin@364_polysilicon-1##11 S1#13pin@364_polysilicon-1##12 9.652
R519 S1#13pin@364_polysilicon-1##12 S1#13pin@364_polysilicon-1##13 9.652
R520 S1#13pin@364_polysilicon-1##13 S1#13pin@364_polysilicon-1##14 9.652
R521 S1#13pin@364_polysilicon-1##14 S1#13pin@364_polysilicon-1##15 9.652
R522 S1#13pin@364_polysilicon-1##15 S1#13pin@364_polysilicon-1##16 9.652
R523 S1#13pin@364_polysilicon-1##16 S1#13pin@364_polysilicon-1##17 9.652
R524 S1#13pin@364_polysilicon-1##17 S1#13pin@364_polysilicon-1##18 9.652
R525 S1#13pin@364_polysilicon-1##18 S1#13pin@364_polysilicon-1##19 9.652
R526 S1#13pin@364_polysilicon-1##19 S1#13pin@364_polysilicon-1##20 9.652
R527 S1#13pin@364_polysilicon-1##20 S1#14pin@401_polysilicon-1 9.652
R528 S1#15pin@373_polysilicon-1 S1#15pin@373_polysilicon-1##0 9.61
R529 S1#15pin@373_polysilicon-1##0 S1#15pin@373_polysilicon-1##1 9.61
R530 S1#15pin@373_polysilicon-1##1 S1#15pin@373_polysilicon-1##2 9.61
R531 S1#15pin@373_polysilicon-1##2 S1#15pin@373_polysilicon-1##3 9.61
R532 S1#15pin@373_polysilicon-1##3 S1#14pin@401_polysilicon-1 9.61
R533 S1#16nmos@53_poly-left S1#16nmos@53_poly-left##0 9.688
R534 S1#16nmos@53_poly-left##0 S1#16nmos@53_poly-left##1 9.688
R535 S1#16nmos@53_poly-left##1 S1#16nmos@53_poly-left##2 9.688
R536 S1#16nmos@53_poly-left##2 S1#13pin@364_polysilicon-1 9.688
R537 net@1143 net@1143 0
R538 net@1143 net@1143 0
R539 S1#17pmos@52_poly-left S1#17pmos@52_poly-left##0 9.688
R540 S1#17pmos@52_poly-left##0 S1#17pmos@52_poly-left##1 9.688
R541 S1#17pmos@52_poly-left##1 S1#17pmos@52_poly-left##2 9.688
R542 S1#17pmos@52_poly-left##2 S1#18pin@363_polysilicon-1 9.688
R543 S1#18pin@363_polysilicon-1 S1#18pin@363_polysilicon-1##0 9.958
R544 S1#18pin@363_polysilicon-1##0 S1#18pin@363_polysilicon-1##1 9.958
R545 S1#18pin@363_polysilicon-1##1 S1#18pin@363_polysilicon-1##2 9.958
R546 S1#18pin@363_polysilicon-1##2 S1#18pin@363_polysilicon-1##3 9.958
R547 S1#18pin@363_polysilicon-1##3 S1#18pin@363_polysilicon-1##4 9.958
R548 S1#18pin@363_polysilicon-1##4 S1#18pin@363_polysilicon-1##5 9.958
R549 S1#18pin@363_polysilicon-1##5 S1#18pin@363_polysilicon-1##6 9.958
R550 S1#18pin@363_polysilicon-1##6 S1#18pin@363_polysilicon-1##7 9.958
R551 S1#18pin@363_polysilicon-1##7 S1#18pin@363_polysilicon-1##8 9.958
R552 S1#18pin@363_polysilicon-1##8 S1#18pin@363_polysilicon-1##9 9.958
R553 S1#18pin@363_polysilicon-1##9 S1#18pin@363_polysilicon-1##10 9.958
R554 S1#18pin@363_polysilicon-1##10 S1#18pin@363_polysilicon-1##11 9.958
R555 S1#18pin@363_polysilicon-1##11 S1#18pin@363_polysilicon-1##12 9.958
R556 S1#18pin@363_polysilicon-1##12 S1#18pin@363_polysilicon-1##13 9.958
R557 S1#18pin@363_polysilicon-1##13 S1#18pin@363_polysilicon-1##14 9.958
R558 S1#18pin@363_polysilicon-1##14 S1#18pin@363_polysilicon-1##15 9.958
R559 S1#18pin@363_polysilicon-1##15 S1#18pin@363_polysilicon-1##16 9.958
R560 S1#18pin@363_polysilicon-1##16 S1#18pin@363_polysilicon-1##17 9.958
R561 S1#18pin@363_polysilicon-1##17 S1#18pin@363_polysilicon-1##18 9.958
R562 S1#18pin@363_polysilicon-1##18 S1#18pin@363_polysilicon-1##19 9.958
R563 S1#18pin@363_polysilicon-1##19 S1#18pin@363_polysilicon-1##20 9.958
R564 S1#18pin@363_polysilicon-1##20 S1#18pin@363_polysilicon-1##21 9.958
R565 S1#18pin@363_polysilicon-1##21 S1#18pin@363_polysilicon-1##22 9.958
R566 S1#18pin@363_polysilicon-1##22 S1#18pin@363_polysilicon-1##23 9.958
R567 S1#18pin@363_polysilicon-1##23 S1#18pin@363_polysilicon-1##24 9.958
R568 S1#18pin@363_polysilicon-1##24 S1#18pin@363_polysilicon-1##25 9.958
R569 S1#18pin@363_polysilicon-1##25 S1#18pin@363_polysilicon-1##26 9.958
R570 S1#18pin@363_polysilicon-1##26 S1#18pin@363_polysilicon-1##27 9.958
R571 S1#18pin@363_polysilicon-1##27 S1#18pin@363_polysilicon-1##28 9.958
R572 S1#18pin@363_polysilicon-1##28 S1#18pin@363_polysilicon-1##29 9.958
R573 S1#18pin@363_polysilicon-1##29 S1#18pin@363_polysilicon-1##30 9.958
R574 S1#18pin@363_polysilicon-1##30 S1#18pin@363_polysilicon-1##31 9.958
R575 S1#18pin@363_polysilicon-1##31 S1#13pin@364_polysilicon-1 9.958
R576 S0#20pmos@48_poly-left S0#20pmos@48_poly-left##0 9.688
R577 S0#20pmos@48_poly-left##0 S0#20pmos@48_poly-left##1 9.688
R578 S0#20pmos@48_poly-left##1 S0#20pmos@48_poly-left##2 9.688
R579 S0#20pmos@48_poly-left##2 S0#21pin@365_polysilicon-1 9.688
R580 net@1144 net@1144 0
R581 net@1111#4contact@434_metal-1-metal-2 net@1111#4contact@434_metal-1-metal-2 0
R582 net@1090#10contact@426_metal-1-n-act net@1090#10contact@426_metal-1-n-act 0
R583 S0#24pmos@55_poly-right S0#24pmos@55_poly-right##0 9.937
R584 S0#24pmos@55_poly-right##0 S0#24pmos@55_poly-right##1 9.937
R585 S0#24pmos@55_poly-right##1 S0#24pmos@55_poly-right##2 9.937
R586 S0#24pmos@55_poly-right##2 S0#24pmos@55_poly-right##3 9.937
R587 S0#24pmos@55_poly-right##3 S0#24pmos@55_poly-right##4 9.937
R588 S0#24pmos@55_poly-right##4 S0#24pmos@55_poly-right##5 9.937
R589 S0#24pmos@55_poly-right##5 S0#24pmos@55_poly-right##6 9.937
R590 S0#24pmos@55_poly-right##6 S0#24pmos@55_poly-right##7 9.937
R591 S0#24pmos@55_poly-right##7 S0#24pmos@55_poly-right##8 9.937
R592 S0#24pmos@55_poly-right##8 S0#24pmos@55_poly-right##9 9.937
R593 S0#24pmos@55_poly-right##9 S0#24pmos@55_poly-right##10 9.937
R594 S0#24pmos@55_poly-right##10 S0#24pmos@55_poly-right##11 9.937
R595 S0#24pmos@55_poly-right##11 S0#24pmos@55_poly-right##12 9.937
R596 S0#24pmos@55_poly-right##12 S0#24pmos@55_poly-right##13 9.937
R597 S0#24pmos@55_poly-right##13 S0#24pmos@55_poly-right##14 9.937
R598 S0#24pmos@55_poly-right##14 S0#24pmos@55_poly-right##15 9.937
R599 S0#24pmos@55_poly-right##15 S0#24pmos@55_poly-right##16 9.937
R600 S0#24pmos@55_poly-right##16 S0#24pmos@55_poly-right##17 9.937
R601 S0#24pmos@55_poly-right##17 S0#24pmos@55_poly-right##18 9.937
R602 S0#24pmos@55_poly-right##18 S0#24pmos@55_poly-right##19 9.937
R603 S0#24pmos@55_poly-right##19 S0#24pmos@55_poly-right##20 9.937
R604 S0#24pmos@55_poly-right##20 S0#24pmos@55_poly-right##21 9.937
R605 S0#24pmos@55_poly-right##21 S0#24pmos@55_poly-right##22 9.937
R606 S0#24pmos@55_poly-right##22 S0#24pmos@55_poly-right##23 9.937
R607 S0#24pmos@55_poly-right##23 S0#24pmos@55_poly-right##24 9.937
R608 S0#24pmos@55_poly-right##24 S0#24pmos@55_poly-right##25 9.937
R609 S0#24pmos@55_poly-right##25 S0#24pmos@55_poly-right##26 9.937
R610 S0#24pmos@55_poly-right##26 S0#24pmos@55_poly-right##27 9.937
R611 S0#24pmos@55_poly-right##27 S0#24pmos@55_poly-right##28 9.937
R612 S0#24pmos@55_poly-right##28 S0#24pmos@55_poly-right##29 9.937
R613 S0#24pmos@55_poly-right##29 S0#24pmos@55_poly-right##30 9.937
R614 S0#24pmos@55_poly-right##30 S0#24pmos@55_poly-right##31 9.937
R615 S0#24pmos@55_poly-right##31 S0#24pmos@55_poly-right##32 9.937
R616 S0#24pmos@55_poly-right##32 S0#24pmos@55_poly-right##33 9.937
R617 S0#24pmos@55_poly-right##33 S0#24pmos@55_poly-right##34 9.937
R618 S0#24pmos@55_poly-right##34 S0#24pmos@55_poly-right##35 9.937
R619 S0#24pmos@55_poly-right##35 S0#24pmos@55_poly-right##36 9.937
R620 S0#24pmos@55_poly-right##36 S0#24pmos@55_poly-right##37 9.937
R621 S0#24pmos@55_poly-right##37 S0#24pmos@55_poly-right##38 9.937
R622 S0#24pmos@55_poly-right##38 S0#24pmos@55_poly-right##39 9.937
R623 S0#24pmos@55_poly-right##39 S0#24pmos@55_poly-right##40 9.937
R624 S0#24pmos@55_poly-right##40 S0#24pmos@55_poly-right##41 9.937
R625 S0#24pmos@55_poly-right##41 S0#24pmos@55_poly-right##42 9.937
R626 S0#24pmos@55_poly-right##42 S0#24pmos@55_poly-right##43 9.937
R627 S0#24pmos@55_poly-right##43 S0#24pmos@55_poly-right##44 9.937
R628 S0#24pmos@55_poly-right##44 S0#24pmos@55_poly-right##45 9.937
R629 S0#24pmos@55_poly-right##45 S0#24pmos@55_poly-right##46 9.937
R630 S0#24pmos@55_poly-right##46 S0#24pmos@55_poly-right##47 9.937
R631 S0#24pmos@55_poly-right##47 S0#24pmos@55_poly-right##48 9.937
R632 S0#24pmos@55_poly-right##48 S0#24pmos@55_poly-right##49 9.937
R633 S0#24pmos@55_poly-right##49 S0#24pmos@55_poly-right##50 9.937
R634 S0#24pmos@55_poly-right##50 S0#24pmos@55_poly-right##51 9.937
R635 S0#24pmos@55_poly-right##51 S0#24pmos@55_poly-right##52 9.937
R636 S0#24pmos@55_poly-right##52 S0#24pmos@55_poly-right##53 9.937
R637 S0#24pmos@55_poly-right##53 S0#24pmos@55_poly-right##54 9.937
R638 S0#24pmos@55_poly-right##54 S0#25pin@370_polysilicon-1 9.937
R639 S0#25pin@370_polysilicon-1 S0#25pin@370_polysilicon-1##0 9.688
R640 S0#25pin@370_polysilicon-1##0 S0#25pin@370_polysilicon-1##1 9.688
R641 S0#25pin@370_polysilicon-1##1 S0#25pin@370_polysilicon-1##2 9.688
R642 S0#25pin@370_polysilicon-1##2 S0#25pin@370_polysilicon-1##3 9.688
R643 S0#25pin@370_polysilicon-1##3 S0#25pin@370_polysilicon-1##4 9.688
R644 S0#25pin@370_polysilicon-1##4 S0#25pin@370_polysilicon-1##5 9.688
R645 S0#25pin@370_polysilicon-1##5 S0#25pin@370_polysilicon-1##6 9.688
R646 S0#25pin@370_polysilicon-1##6 S0#26nmos@55_poly-right 9.688
R647 net@1144 net@1144 0
R648 S0#22contact@428_metal-1-metal-2 S0#22contact@428_metal-1-metal-2##0 9.864
R649 S0#22contact@428_metal-1-metal-2##0 S0#22contact@428_metal-1-metal-2##1 9.864
R650 S0#22contact@428_metal-1-metal-2##1 S0#22contact@428_metal-1-metal-2##2 9.864
R651 S0#22contact@428_metal-1-metal-2##2 S0#22contact@428_metal-1-metal-2##3 9.864
R652 S0#22contact@428_metal-1-metal-2##3 S0#22contact@428_metal-1-metal-2##4 9.864
R653 S0#22contact@428_metal-1-metal-2##4 S0#22contact@428_metal-1-metal-2##5 9.864
R654 S0#22contact@428_metal-1-metal-2##5 S0#22contact@428_metal-1-metal-2##6 9.864
R655 S0#22contact@428_metal-1-metal-2##6 S0#22contact@428_metal-1-metal-2##7 9.864
R656 S0#22contact@428_metal-1-metal-2##7 S0#22contact@428_metal-1-metal-2##8 9.864
R657 S0#22contact@428_metal-1-metal-2##8 S0#22contact@428_metal-1-metal-2##9 9.864
R658 S0#22contact@428_metal-1-metal-2##9 S0#25pin@370_polysilicon-1 9.864
R659 net@1090#5contact@432_metal-1-metal-2 net@1090#10contact@426_metal-1-n-act 4.927
R660 S1#15pin@373_polysilicon-1 S1#15pin@373_polysilicon-1##0 9.688
R661 S1#15pin@373_polysilicon-1##0 S1#15pin@373_polysilicon-1##1 9.688
R662 S1#15pin@373_polysilicon-1##1 S1#15pin@373_polysilicon-1##2 9.688
R663 S1#15pin@373_polysilicon-1##2 S1#15pin@373_polysilicon-1##3 9.688
R664 S1#15pin@373_polysilicon-1##3 S1#15pin@373_polysilicon-1##4 9.688
R665 S1#15pin@373_polysilicon-1##4 S1#15pin@373_polysilicon-1##5 9.688
R666 S1#15pin@373_polysilicon-1##5 S1#15pin@373_polysilicon-1##6 9.688
R667 S1#15pin@373_polysilicon-1##6 S1#15pin@373_polysilicon-1##7 9.688
R668 S1#15pin@373_polysilicon-1##7 S1#15pin@373_polysilicon-1##8 9.688
R669 S1#15pin@373_polysilicon-1##8 S1#15pin@373_polysilicon-1##9 9.688
R670 S1#15pin@373_polysilicon-1##9 S1#15pin@373_polysilicon-1##10 9.688
R671 S1#15pin@373_polysilicon-1##10 S1#15pin@373_polysilicon-1##11 9.688
R672 S1#15pin@373_polysilicon-1##11 S1#15pin@373_polysilicon-1##12 9.688
R673 S1#15pin@373_polysilicon-1##12 S1#15pin@373_polysilicon-1##13 9.688
R674 S1#15pin@373_polysilicon-1##13 S1#15pin@373_polysilicon-1##14 9.688
R675 S1#15pin@373_polysilicon-1##14 S1#15pin@373_polysilicon-1##15 9.688
R676 S1#15pin@373_polysilicon-1##15 S1#15pin@373_polysilicon-1##16 9.688
R677 S1#15pin@373_polysilicon-1##16 S1#15pin@373_polysilicon-1##17 9.688
R678 S1#15pin@373_polysilicon-1##17 S1#15pin@373_polysilicon-1##18 9.688
R679 S1#15pin@373_polysilicon-1##18 S1#15pin@373_polysilicon-1##19 9.688
R680 S1#15pin@373_polysilicon-1##19 S1#15pin@373_polysilicon-1##20 9.688
R681 S1#15pin@373_polysilicon-1##20 S1#15pin@373_polysilicon-1##21 9.688
R682 S1#15pin@373_polysilicon-1##21 S1#15pin@373_polysilicon-1##22 9.688
R683 S1#15pin@373_polysilicon-1##22 S1#15pin@373_polysilicon-1##23 9.688
R684 S1#15pin@373_polysilicon-1##23 S1#15pin@373_polysilicon-1##24 9.688
R685 S1#15pin@373_polysilicon-1##24 S1#15pin@373_polysilicon-1##25 9.688
R686 S1#15pin@373_polysilicon-1##25 S1#15pin@373_polysilicon-1##26 9.688
R687 S1#15pin@373_polysilicon-1##26 S1#19pin@374_polysilicon-1 9.688
R688 S1#23pmos@54_poly-right S1#23pmos@54_poly-right##0 9.89
R689 S1#23pmos@54_poly-right##0 S1#23pmos@54_poly-right##1 9.89
R690 S1#23pmos@54_poly-right##1 S1#23pmos@54_poly-right##2 9.89
R691 S1#23pmos@54_poly-right##2 S1#23pmos@54_poly-right##3 9.89
R692 S1#23pmos@54_poly-right##3 S1#23pmos@54_poly-right##4 9.89
R693 S1#23pmos@54_poly-right##4 S1#23pmos@54_poly-right##5 9.89
R694 S1#23pmos@54_poly-right##5 S1#23pmos@54_poly-right##6 9.89
R695 S1#23pmos@54_poly-right##6 S1#23pmos@54_poly-right##7 9.89
R696 S1#23pmos@54_poly-right##7 S1#23pmos@54_poly-right##8 9.89
R697 S1#23pmos@54_poly-right##8 S1#23pmos@54_poly-right##9 9.89
R698 S1#23pmos@54_poly-right##9 S1#23pmos@54_poly-right##10 9.89
R699 S1#23pmos@54_poly-right##10 S1#23pmos@54_poly-right##11 9.89
R700 S1#23pmos@54_poly-right##11 S1#23pmos@54_poly-right##12 9.89
R701 S1#23pmos@54_poly-right##12 S1#23pmos@54_poly-right##13 9.89
R702 S1#23pmos@54_poly-right##13 S1#23pmos@54_poly-right##14 9.89
R703 S1#23pmos@54_poly-right##14 S1#23pmos@54_poly-right##15 9.89
R704 S1#23pmos@54_poly-right##15 S1#23pmos@54_poly-right##16 9.89
R705 S1#23pmos@54_poly-right##16 S1#23pmos@54_poly-right##17 9.89
R706 S1#23pmos@54_poly-right##17 S1#23pmos@54_poly-right##18 9.89
R707 S1#23pmos@54_poly-right##18 S1#23pmos@54_poly-right##19 9.89
R708 S1#23pmos@54_poly-right##19 S1#23pmos@54_poly-right##20 9.89
R709 S1#23pmos@54_poly-right##20 S1#23pmos@54_poly-right##21 9.89
R710 S1#23pmos@54_poly-right##21 S1#23pmos@54_poly-right##22 9.89
R711 S1#23pmos@54_poly-right##22 S1#23pmos@54_poly-right##23 9.89
R712 S1#23pmos@54_poly-right##23 S1#23pmos@54_poly-right##24 9.89
R713 S1#23pmos@54_poly-right##24 S1#23pmos@54_poly-right##25 9.89
R714 S1#23pmos@54_poly-right##25 S1#23pmos@54_poly-right##26 9.89
R715 S1#23pmos@54_poly-right##26 S1#23pmos@54_poly-right##27 9.89
R716 S1#23pmos@54_poly-right##27 S1#23pmos@54_poly-right##28 9.89
R717 S1#23pmos@54_poly-right##28 S1#23pmos@54_poly-right##29 9.89
R718 S1#23pmos@54_poly-right##29 S1#23pmos@54_poly-right##30 9.89
R719 S1#23pmos@54_poly-right##30 S1#23pmos@54_poly-right##31 9.89
R720 S1#23pmos@54_poly-right##31 S1#23pmos@54_poly-right##32 9.89
R721 S1#23pmos@54_poly-right##32 S1#23pmos@54_poly-right##33 9.89
R722 S1#23pmos@54_poly-right##33 S1#23pmos@54_poly-right##34 9.89
R723 S1#23pmos@54_poly-right##34 S1#23pmos@54_poly-right##35 9.89
R724 S1#23pmos@54_poly-right##35 S1#23pmos@54_poly-right##36 9.89
R725 S1#23pmos@54_poly-right##36 S1#23pmos@54_poly-right##37 9.89
R726 S1#23pmos@54_poly-right##37 S1#23pmos@54_poly-right##38 9.89
R727 S1#23pmos@54_poly-right##38 S1#23pmos@54_poly-right##39 9.89
R728 S1#23pmos@54_poly-right##39 S1#23pmos@54_poly-right##40 9.89
R729 S1#23pmos@54_poly-right##40 S1#23pmos@54_poly-right##41 9.89
R730 S1#23pmos@54_poly-right##41 S1#23pmos@54_poly-right##42 9.89
R731 S1#23pmos@54_poly-right##42 S1#23pmos@54_poly-right##43 9.89
R732 S1#23pmos@54_poly-right##43 S1#23pmos@54_poly-right##44 9.89
R733 S1#23pmos@54_poly-right##44 S1#23pmos@54_poly-right##45 9.89
R734 S1#23pmos@54_poly-right##45 S1#23pmos@54_poly-right##46 9.89
R735 S1#23pmos@54_poly-right##46 S1#23pmos@54_poly-right##47 9.89
R736 S1#23pmos@54_poly-right##47 S1#23pmos@54_poly-right##48 9.89
R737 S1#23pmos@54_poly-right##48 S1#23pmos@54_poly-right##49 9.89
R738 S1#23pmos@54_poly-right##49 S1#23pmos@54_poly-right##50 9.89
R739 S1#23pmos@54_poly-right##50 S1#23pmos@54_poly-right##51 9.89
R740 S1#23pmos@54_poly-right##51 S1#23pmos@54_poly-right##52 9.89
R741 S1#23pmos@54_poly-right##52 S1#23pmos@54_poly-right##53 9.89
R742 S1#23pmos@54_poly-right##53 S1#23pmos@54_poly-right##54 9.89
R743 S1#23pmos@54_poly-right##54 S1#23pmos@54_poly-right##55 9.89
R744 S1#23pmos@54_poly-right##55 S1#23pmos@54_poly-right##56 9.89
R745 S1#23pmos@54_poly-right##56 S1#23pmos@54_poly-right##57 9.89
R746 S1#23pmos@54_poly-right##57 S1#23pmos@54_poly-right##58 9.89
R747 S1#23pmos@54_poly-right##58 S1#23pmos@54_poly-right##59 9.89
R748 S1#23pmos@54_poly-right##59 S1#23pmos@54_poly-right##60 9.89
R749 S1#23pmos@54_poly-right##60 S1#23pmos@54_poly-right##61 9.89
R750 S1#23pmos@54_poly-right##61 S1#24pin@376_polysilicon-1 9.89
R751 S1#24pin@376_polysilicon-1 S1#19pin@374_polysilicon-1 7.75
R752 S1#21contact@438_metal-1-metal-2 S1#21contact@438_metal-1-metal-2##0 5.425
R753 S1#21contact@438_metal-1-metal-2##0 S1#24pin@376_polysilicon-1 5.425
R754 net@1090#14pmos@51_poly-left net@1090#14pmos@51_poly-left##0 9.688
R755 net@1090#14pmos@51_poly-left##0 net@1090#14pmos@51_poly-left##1 9.688
R756 net@1090#14pmos@51_poly-left##1 net@1090#14pmos@51_poly-left##2 9.688
R757 net@1090#14pmos@51_poly-left##2 net@1090#15pin@383_polysilicon-1 9.688
R758 net@1090#15pin@383_polysilicon-1 net@1090#15pin@383_polysilicon-1##0 9.946
R759 net@1090#15pin@383_polysilicon-1##0 net@1090#15pin@383_polysilicon-1##1 9.946
R760 net@1090#15pin@383_polysilicon-1##1 net@1090#15pin@383_polysilicon-1##2 9.946
R761 net@1090#15pin@383_polysilicon-1##2 net@1090#15pin@383_polysilicon-1##3 9.946
R762 net@1090#15pin@383_polysilicon-1##3 net@1090#15pin@383_polysilicon-1##4 9.946
R763 net@1090#15pin@383_polysilicon-1##4 net@1090#15pin@383_polysilicon-1##5 9.946
R764 net@1090#15pin@383_polysilicon-1##5 net@1090#15pin@383_polysilicon-1##6 9.946
R765 net@1090#15pin@383_polysilicon-1##6 net@1090#15pin@383_polysilicon-1##7 9.946
R766 net@1090#15pin@383_polysilicon-1##7 net@1090#15pin@383_polysilicon-1##8 9.946
R767 net@1090#15pin@383_polysilicon-1##8 net@1090#15pin@383_polysilicon-1##9 9.946
R768 net@1090#15pin@383_polysilicon-1##9 net@1090#15pin@383_polysilicon-1##10 9.946
R769 net@1090#15pin@383_polysilicon-1##10 net@1090#16pin@384_polysilicon-1 9.946
R770 S0#32nmos@51_poly-left S0#32nmos@51_poly-left##0 9.688
R771 S0#32nmos@51_poly-left##0 S0#32nmos@51_poly-left##1 9.688
R772 S0#32nmos@51_poly-left##1 S0#32nmos@51_poly-left##2 9.688
R773 S0#32nmos@51_poly-left##2 S0#33pin@385_polysilicon-1 9.688
R774 S0#22contact@428_metal-1-metal-2 S0#22contact@428_metal-1-metal-2##0 9.429
R775 S0#22contact@428_metal-1-metal-2##0 S0#22contact@428_metal-1-metal-2##1 9.429
R776 S0#22contact@428_metal-1-metal-2##1 S0#22contact@428_metal-1-metal-2##2 9.429
R777 S0#22contact@428_metal-1-metal-2##2 S0#22contact@428_metal-1-metal-2##3 9.429
R778 S0#22contact@428_metal-1-metal-2##3 S0#22contact@428_metal-1-metal-2##4 9.429
R779 S0#22contact@428_metal-1-metal-2##4 S0#22contact@428_metal-1-metal-2##5 9.429
R780 S0#22contact@428_metal-1-metal-2##5 S0#22contact@428_metal-1-metal-2##6 9.429
R781 S0#22contact@428_metal-1-metal-2##6 S0#22contact@428_metal-1-metal-2##7 9.429
R782 S0#22contact@428_metal-1-metal-2##7 S0#22contact@428_metal-1-metal-2##8 9.429
R783 S0#22contact@428_metal-1-metal-2##8 S0#22contact@428_metal-1-metal-2##9 9.429
R784 S0#22contact@428_metal-1-metal-2##9 S0#22contact@428_metal-1-metal-2##10 9.429
R785 S0#22contact@428_metal-1-metal-2##10 S0#32nmos@51_poly-left 9.429
R786 net@1090#1pin@388_polysilicon-1 net@1090#1pin@388_polysilicon-1##0 5.425
R787 net@1090#1pin@388_polysilicon-1##0 net@1090#16pin@384_polysilicon-1 5.425
R788 net@1090#18nmos@50_poly-right net@1090#18nmos@50_poly-right##0 9.688
R789 net@1090#18nmos@50_poly-right##0 net@1090#18nmos@50_poly-right##1 9.688
R790 net@1090#18nmos@50_poly-right##1 net@1090#18nmos@50_poly-right##2 9.688
R791 net@1090#18nmos@50_poly-right##2 net@1090#1pin@388_polysilicon-1 9.688
R792 S0#19pin@391_polysilicon-1 S0#19pin@391_polysilicon-1##0 9.521
R793 S0#19pin@391_polysilicon-1##0 S0#19pin@391_polysilicon-1##1 9.521
R794 S0#19pin@391_polysilicon-1##1 S0#19pin@391_polysilicon-1##2 9.521
R795 S0#19pin@391_polysilicon-1##2 S0#19pin@391_polysilicon-1##3 9.521
R796 S0#19pin@391_polysilicon-1##3 S0#19pin@391_polysilicon-1##4 9.521
R797 S0#19pin@391_polysilicon-1##4 S0#19pin@391_polysilicon-1##5 9.521
R798 S0#19pin@391_polysilicon-1##5 S0#34pin@389_polysilicon-1 9.521
R799 S0#34pin@389_polysilicon-1 S0#34pin@389_polysilicon-1##0 9.868
R800 S0#34pin@389_polysilicon-1##0 S0#34pin@389_polysilicon-1##1 9.868
R801 S0#34pin@389_polysilicon-1##1 S0#34pin@389_polysilicon-1##2 9.868
R802 S0#34pin@389_polysilicon-1##2 S0#34pin@389_polysilicon-1##3 9.868
R803 S0#34pin@389_polysilicon-1##3 S0#34pin@389_polysilicon-1##4 9.868
R804 S0#34pin@389_polysilicon-1##4 S0#34pin@389_polysilicon-1##5 9.868
R805 S0#34pin@389_polysilicon-1##5 S0#34pin@389_polysilicon-1##6 9.868
R806 S0#34pin@389_polysilicon-1##6 S0#34pin@389_polysilicon-1##7 9.868
R807 S0#34pin@389_polysilicon-1##7 S0#34pin@389_polysilicon-1##8 9.868
R808 S0#34pin@389_polysilicon-1##8 S0#34pin@389_polysilicon-1##9 9.868
R809 S0#34pin@389_polysilicon-1##9 S0#34pin@389_polysilicon-1##10 9.868
R810 S0#34pin@389_polysilicon-1##10 S0#34pin@389_polysilicon-1##11 9.868
R811 S0#34pin@389_polysilicon-1##11 S0#34pin@389_polysilicon-1##12 9.868
R812 S0#34pin@389_polysilicon-1##12 S0#34pin@389_polysilicon-1##13 9.868
R813 S0#34pin@389_polysilicon-1##13 S0#34pin@389_polysilicon-1##14 9.868
R814 S0#34pin@389_polysilicon-1##14 S0#34pin@389_polysilicon-1##15 9.868
R815 S0#34pin@389_polysilicon-1##15 S0#34pin@389_polysilicon-1##16 9.868
R816 S0#34pin@389_polysilicon-1##16 S0#34pin@389_polysilicon-1##17 9.868
R817 S0#34pin@389_polysilicon-1##17 S0#34pin@389_polysilicon-1##18 9.868
R818 S0#34pin@389_polysilicon-1##18 S0#34pin@389_polysilicon-1##19 9.868
R819 S0#34pin@389_polysilicon-1##19 S0#34pin@389_polysilicon-1##20 9.868
R820 S0#34pin@389_polysilicon-1##20 S0#34pin@389_polysilicon-1##21 9.868
R821 S0#34pin@389_polysilicon-1##21 S0#34pin@389_polysilicon-1##22 9.868
R822 S0#34pin@389_polysilicon-1##22 S0#34pin@389_polysilicon-1##23 9.868
R823 S0#34pin@389_polysilicon-1##23 S0#34pin@389_polysilicon-1##24 9.868
R824 S0#34pin@389_polysilicon-1##24 S0#34pin@389_polysilicon-1##25 9.868
R825 S0#34pin@389_polysilicon-1##25 S0#34pin@389_polysilicon-1##26 9.868
R826 S0#34pin@389_polysilicon-1##26 S0#34pin@389_polysilicon-1##27 9.868
R827 S0#34pin@389_polysilicon-1##27 S0#34pin@389_polysilicon-1##28 9.868
R828 S0#34pin@389_polysilicon-1##28 S0#33pin@385_polysilicon-1 9.868
R829 S0#35pmos@50_poly-left S0#35pmos@50_poly-left##0 9.688
R830 S0#35pmos@50_poly-left##0 S0#35pmos@50_poly-left##1 9.688
R831 S0#35pmos@50_poly-left##1 S0#35pmos@50_poly-left##2 9.688
R832 S0#35pmos@50_poly-left##2 S0#34pin@389_polysilicon-1 9.688
R833 net@1112 net@1112 0
R834 S0#21pin@365_polysilicon-1 S0#21pin@365_polysilicon-1##0 9.972
R835 S0#21pin@365_polysilicon-1##0 S0#21pin@365_polysilicon-1##1 9.972
R836 S0#21pin@365_polysilicon-1##1 S0#21pin@365_polysilicon-1##2 9.972
R837 S0#21pin@365_polysilicon-1##2 S0#21pin@365_polysilicon-1##3 9.972
R838 S0#21pin@365_polysilicon-1##3 S0#21pin@365_polysilicon-1##4 9.972
R839 S0#21pin@365_polysilicon-1##4 S0#21pin@365_polysilicon-1##5 9.972
R840 S0#21pin@365_polysilicon-1##5 S0#21pin@365_polysilicon-1##6 9.972
R841 S0#21pin@365_polysilicon-1##6 S0#21pin@365_polysilicon-1##7 9.972
R842 S0#21pin@365_polysilicon-1##7 S0#21pin@365_polysilicon-1##8 9.972
R843 S0#21pin@365_polysilicon-1##8 S0#21pin@365_polysilicon-1##9 9.972
R844 S0#21pin@365_polysilicon-1##9 S0#21pin@365_polysilicon-1##10 9.972
R845 S0#21pin@365_polysilicon-1##10 S0#21pin@365_polysilicon-1##11 9.972
R846 S0#21pin@365_polysilicon-1##11 S0#21pin@365_polysilicon-1##12 9.972
R847 S0#21pin@365_polysilicon-1##12 S0#21pin@365_polysilicon-1##13 9.972
R848 S0#21pin@365_polysilicon-1##13 S0#21pin@365_polysilicon-1##14 9.972
R849 S0#21pin@365_polysilicon-1##14 S0#21pin@365_polysilicon-1##15 9.972
R850 S0#21pin@365_polysilicon-1##15 S0#21pin@365_polysilicon-1##16 9.972
R851 S0#21pin@365_polysilicon-1##16 S0#21pin@365_polysilicon-1##17 9.972
R852 S0#21pin@365_polysilicon-1##17 S0#21pin@365_polysilicon-1##18 9.972
R853 S0#21pin@365_polysilicon-1##18 S0#21pin@365_polysilicon-1##19 9.972
R854 S0#21pin@365_polysilicon-1##19 S0#21pin@365_polysilicon-1##20 9.972
R855 S0#21pin@365_polysilicon-1##20 S0#21pin@365_polysilicon-1##21 9.972
R856 S0#21pin@365_polysilicon-1##21 S0#21pin@365_polysilicon-1##22 9.972
R857 S0#21pin@365_polysilicon-1##22 S0#21pin@365_polysilicon-1##23 9.972
R858 S0#21pin@365_polysilicon-1##23 S0#21pin@365_polysilicon-1##24 9.972
R859 S0#21pin@365_polysilicon-1##24 S0#21pin@365_polysilicon-1##25 9.972
R860 S0#21pin@365_polysilicon-1##25 S0#21pin@365_polysilicon-1##26 9.972
R861 S0#21pin@365_polysilicon-1##26 S0#21pin@365_polysilicon-1##27 9.972
R862 S0#21pin@365_polysilicon-1##27 S0#21pin@365_polysilicon-1##28 9.972
R863 S0#21pin@365_polysilicon-1##28 S0#19pin@391_polysilicon-1 9.972
R864 net@1271 net@1271 0
R865 net@1276#2contact@492_metal-1-n-act net@1276#2contact@492_metal-1-n-act 0
R866 S0#38pmos@63_poly-right S0#38pmos@63_poly-right##0 9.937
R867 S0#38pmos@63_poly-right##0 S0#38pmos@63_poly-right##1 9.937
R868 S0#38pmos@63_poly-right##1 S0#38pmos@63_poly-right##2 9.937
R869 S0#38pmos@63_poly-right##2 S0#38pmos@63_poly-right##3 9.937
R870 S0#38pmos@63_poly-right##3 S0#38pmos@63_poly-right##4 9.937
R871 S0#38pmos@63_poly-right##4 S0#38pmos@63_poly-right##5 9.937
R872 S0#38pmos@63_poly-right##5 S0#38pmos@63_poly-right##6 9.937
R873 S0#38pmos@63_poly-right##6 S0#38pmos@63_poly-right##7 9.937
R874 S0#38pmos@63_poly-right##7 S0#38pmos@63_poly-right##8 9.937
R875 S0#38pmos@63_poly-right##8 S0#38pmos@63_poly-right##9 9.937
R876 S0#38pmos@63_poly-right##9 S0#38pmos@63_poly-right##10 9.937
R877 S0#38pmos@63_poly-right##10 S0#38pmos@63_poly-right##11 9.937
R878 S0#38pmos@63_poly-right##11 S0#38pmos@63_poly-right##12 9.937
R879 S0#38pmos@63_poly-right##12 S0#38pmos@63_poly-right##13 9.937
R880 S0#38pmos@63_poly-right##13 S0#38pmos@63_poly-right##14 9.937
R881 S0#38pmos@63_poly-right##14 S0#38pmos@63_poly-right##15 9.937
R882 S0#38pmos@63_poly-right##15 S0#38pmos@63_poly-right##16 9.937
R883 S0#38pmos@63_poly-right##16 S0#38pmos@63_poly-right##17 9.937
R884 S0#38pmos@63_poly-right##17 S0#38pmos@63_poly-right##18 9.937
R885 S0#38pmos@63_poly-right##18 S0#38pmos@63_poly-right##19 9.937
R886 S0#38pmos@63_poly-right##19 S0#38pmos@63_poly-right##20 9.937
R887 S0#38pmos@63_poly-right##20 S0#38pmos@63_poly-right##21 9.937
R888 S0#38pmos@63_poly-right##21 S0#38pmos@63_poly-right##22 9.937
R889 S0#38pmos@63_poly-right##22 S0#38pmos@63_poly-right##23 9.937
R890 S0#38pmos@63_poly-right##23 S0#38pmos@63_poly-right##24 9.937
R891 S0#38pmos@63_poly-right##24 S0#38pmos@63_poly-right##25 9.937
R892 S0#38pmos@63_poly-right##25 S0#38pmos@63_poly-right##26 9.937
R893 S0#38pmos@63_poly-right##26 S0#38pmos@63_poly-right##27 9.937
R894 S0#38pmos@63_poly-right##27 S0#38pmos@63_poly-right##28 9.937
R895 S0#38pmos@63_poly-right##28 S0#38pmos@63_poly-right##29 9.937
R896 S0#38pmos@63_poly-right##29 S0#38pmos@63_poly-right##30 9.937
R897 S0#38pmos@63_poly-right##30 S0#38pmos@63_poly-right##31 9.937
R898 S0#38pmos@63_poly-right##31 S0#38pmos@63_poly-right##32 9.937
R899 S0#38pmos@63_poly-right##32 S0#38pmos@63_poly-right##33 9.937
R900 S0#38pmos@63_poly-right##33 S0#38pmos@63_poly-right##34 9.937
R901 S0#38pmos@63_poly-right##34 S0#38pmos@63_poly-right##35 9.937
R902 S0#38pmos@63_poly-right##35 S0#38pmos@63_poly-right##36 9.937
R903 S0#38pmos@63_poly-right##36 S0#38pmos@63_poly-right##37 9.937
R904 S0#38pmos@63_poly-right##37 S0#38pmos@63_poly-right##38 9.937
R905 S0#38pmos@63_poly-right##38 S0#38pmos@63_poly-right##39 9.937
R906 S0#38pmos@63_poly-right##39 S0#38pmos@63_poly-right##40 9.937
R907 S0#38pmos@63_poly-right##40 S0#38pmos@63_poly-right##41 9.937
R908 S0#38pmos@63_poly-right##41 S0#38pmos@63_poly-right##42 9.937
R909 S0#38pmos@63_poly-right##42 S0#38pmos@63_poly-right##43 9.937
R910 S0#38pmos@63_poly-right##43 S0#38pmos@63_poly-right##44 9.937
R911 S0#38pmos@63_poly-right##44 S0#38pmos@63_poly-right##45 9.937
R912 S0#38pmos@63_poly-right##45 S0#38pmos@63_poly-right##46 9.937
R913 S0#38pmos@63_poly-right##46 S0#38pmos@63_poly-right##47 9.937
R914 S0#38pmos@63_poly-right##47 S0#38pmos@63_poly-right##48 9.937
R915 S0#38pmos@63_poly-right##48 S0#38pmos@63_poly-right##49 9.937
R916 S0#38pmos@63_poly-right##49 S0#38pmos@63_poly-right##50 9.937
R917 S0#38pmos@63_poly-right##50 S0#38pmos@63_poly-right##51 9.937
R918 S0#38pmos@63_poly-right##51 S0#38pmos@63_poly-right##52 9.937
R919 S0#38pmos@63_poly-right##52 S0#38pmos@63_poly-right##53 9.937
R920 S0#38pmos@63_poly-right##53 S0#38pmos@63_poly-right##54 9.937
R921 S0#38pmos@63_poly-right##54 S0#39pin@428_polysilicon-1 9.937
R922 S0#39pin@428_polysilicon-1 S0#39pin@428_polysilicon-1##0 9.688
R923 S0#39pin@428_polysilicon-1##0 S0#39pin@428_polysilicon-1##1 9.688
R924 S0#39pin@428_polysilicon-1##1 S0#39pin@428_polysilicon-1##2 9.688
R925 S0#39pin@428_polysilicon-1##2 S0#39pin@428_polysilicon-1##3 9.688
R926 S0#39pin@428_polysilicon-1##3 S0#39pin@428_polysilicon-1##4 9.688
R927 S0#39pin@428_polysilicon-1##4 S0#39pin@428_polysilicon-1##5 9.688
R928 S0#39pin@428_polysilicon-1##5 S0#39pin@428_polysilicon-1##6 9.688
R929 S0#39pin@428_polysilicon-1##6 S0#40nmos@63_poly-right 9.688
R930 net@1273 net@1273 0
R931 S0#36contact@494_metal-1-metal-2 S0#36contact@494_metal-1-metal-2##0 9.864
R932 S0#36contact@494_metal-1-metal-2##0 S0#36contact@494_metal-1-metal-2##1 9.864
R933 S0#36contact@494_metal-1-metal-2##1 S0#36contact@494_metal-1-metal-2##2 9.864
R934 S0#36contact@494_metal-1-metal-2##2 S0#36contact@494_metal-1-metal-2##3 9.864
R935 S0#36contact@494_metal-1-metal-2##3 S0#36contact@494_metal-1-metal-2##4 9.864
R936 S0#36contact@494_metal-1-metal-2##4 S0#36contact@494_metal-1-metal-2##5 9.864
R937 S0#36contact@494_metal-1-metal-2##5 S0#36contact@494_metal-1-metal-2##6 9.864
R938 S0#36contact@494_metal-1-metal-2##6 S0#36contact@494_metal-1-metal-2##7 9.864
R939 S0#36contact@494_metal-1-metal-2##7 S0#36contact@494_metal-1-metal-2##8 9.864
R940 S0#36contact@494_metal-1-metal-2##8 S0#36contact@494_metal-1-metal-2##9 9.864
R941 S0#36contact@494_metal-1-metal-2##9 S0#39pin@428_polysilicon-1 9.864
R942 net@1276 net@1276#2contact@492_metal-1-n-act 4.927
R943 S1#28pin@431_polysilicon-1 S1#28pin@431_polysilicon-1##0 9.688
R944 S1#28pin@431_polysilicon-1##0 S1#28pin@431_polysilicon-1##1 9.688
R945 S1#28pin@431_polysilicon-1##1 S1#28pin@431_polysilicon-1##2 9.688
R946 S1#28pin@431_polysilicon-1##2 S1#28pin@431_polysilicon-1##3 9.688
R947 S1#28pin@431_polysilicon-1##3 S1#28pin@431_polysilicon-1##4 9.688
R948 S1#28pin@431_polysilicon-1##4 S1#28pin@431_polysilicon-1##5 9.688
R949 S1#28pin@431_polysilicon-1##5 S1#28pin@431_polysilicon-1##6 9.688
R950 S1#28pin@431_polysilicon-1##6 S1#28pin@431_polysilicon-1##7 9.688
R951 S1#28pin@431_polysilicon-1##7 S1#28pin@431_polysilicon-1##8 9.688
R952 S1#28pin@431_polysilicon-1##8 S1#28pin@431_polysilicon-1##9 9.688
R953 S1#28pin@431_polysilicon-1##9 S1#28pin@431_polysilicon-1##10 9.688
R954 S1#28pin@431_polysilicon-1##10 S1#28pin@431_polysilicon-1##11 9.688
R955 S1#28pin@431_polysilicon-1##11 S1#28pin@431_polysilicon-1##12 9.688
R956 S1#28pin@431_polysilicon-1##12 S1#28pin@431_polysilicon-1##13 9.688
R957 S1#28pin@431_polysilicon-1##13 S1#28pin@431_polysilicon-1##14 9.688
R958 S1#28pin@431_polysilicon-1##14 S1#28pin@431_polysilicon-1##15 9.688
R959 S1#28pin@431_polysilicon-1##15 S1#28pin@431_polysilicon-1##16 9.688
R960 S1#28pin@431_polysilicon-1##16 S1#28pin@431_polysilicon-1##17 9.688
R961 S1#28pin@431_polysilicon-1##17 S1#28pin@431_polysilicon-1##18 9.688
R962 S1#28pin@431_polysilicon-1##18 S1#28pin@431_polysilicon-1##19 9.688
R963 S1#28pin@431_polysilicon-1##19 S1#28pin@431_polysilicon-1##20 9.688
R964 S1#28pin@431_polysilicon-1##20 S1#28pin@431_polysilicon-1##21 9.688
R965 S1#28pin@431_polysilicon-1##21 S1#28pin@431_polysilicon-1##22 9.688
R966 S1#28pin@431_polysilicon-1##22 S1#28pin@431_polysilicon-1##23 9.688
R967 S1#28pin@431_polysilicon-1##23 S1#28pin@431_polysilicon-1##24 9.688
R968 S1#28pin@431_polysilicon-1##24 S1#28pin@431_polysilicon-1##25 9.688
R969 S1#28pin@431_polysilicon-1##25 S1#28pin@431_polysilicon-1##26 9.688
R970 S1#28pin@431_polysilicon-1##26 S1#26pin@432_polysilicon-1 9.688
R971 S1#31pmos@62_poly-right S1#31pmos@62_poly-right##0 9.89
R972 S1#31pmos@62_poly-right##0 S1#31pmos@62_poly-right##1 9.89
R973 S1#31pmos@62_poly-right##1 S1#31pmos@62_poly-right##2 9.89
R974 S1#31pmos@62_poly-right##2 S1#31pmos@62_poly-right##3 9.89
R975 S1#31pmos@62_poly-right##3 S1#31pmos@62_poly-right##4 9.89
R976 S1#31pmos@62_poly-right##4 S1#31pmos@62_poly-right##5 9.89
R977 S1#31pmos@62_poly-right##5 S1#31pmos@62_poly-right##6 9.89
R978 S1#31pmos@62_poly-right##6 S1#31pmos@62_poly-right##7 9.89
R979 S1#31pmos@62_poly-right##7 S1#31pmos@62_poly-right##8 9.89
R980 S1#31pmos@62_poly-right##8 S1#31pmos@62_poly-right##9 9.89
R981 S1#31pmos@62_poly-right##9 S1#31pmos@62_poly-right##10 9.89
R982 S1#31pmos@62_poly-right##10 S1#31pmos@62_poly-right##11 9.89
R983 S1#31pmos@62_poly-right##11 S1#31pmos@62_poly-right##12 9.89
R984 S1#31pmos@62_poly-right##12 S1#31pmos@62_poly-right##13 9.89
R985 S1#31pmos@62_poly-right##13 S1#31pmos@62_poly-right##14 9.89
R986 S1#31pmos@62_poly-right##14 S1#31pmos@62_poly-right##15 9.89
R987 S1#31pmos@62_poly-right##15 S1#31pmos@62_poly-right##16 9.89
R988 S1#31pmos@62_poly-right##16 S1#31pmos@62_poly-right##17 9.89
R989 S1#31pmos@62_poly-right##17 S1#31pmos@62_poly-right##18 9.89
R990 S1#31pmos@62_poly-right##18 S1#31pmos@62_poly-right##19 9.89
R991 S1#31pmos@62_poly-right##19 S1#31pmos@62_poly-right##20 9.89
R992 S1#31pmos@62_poly-right##20 S1#31pmos@62_poly-right##21 9.89
R993 S1#31pmos@62_poly-right##21 S1#31pmos@62_poly-right##22 9.89
R994 S1#31pmos@62_poly-right##22 S1#31pmos@62_poly-right##23 9.89
R995 S1#31pmos@62_poly-right##23 S1#31pmos@62_poly-right##24 9.89
R996 S1#31pmos@62_poly-right##24 S1#31pmos@62_poly-right##25 9.89
R997 S1#31pmos@62_poly-right##25 S1#31pmos@62_poly-right##26 9.89
R998 S1#31pmos@62_poly-right##26 S1#31pmos@62_poly-right##27 9.89
R999 S1#31pmos@62_poly-right##27 S1#31pmos@62_poly-right##28 9.89
R1000 S1#31pmos@62_poly-right##28 S1#31pmos@62_poly-right##29 9.89
R1001 S1#31pmos@62_poly-right##29 S1#31pmos@62_poly-right##30 9.89
R1002 S1#31pmos@62_poly-right##30 S1#31pmos@62_poly-right##31 9.89
R1003 S1#31pmos@62_poly-right##31 S1#31pmos@62_poly-right##32 9.89
R1004 S1#31pmos@62_poly-right##32 S1#31pmos@62_poly-right##33 9.89
R1005 S1#31pmos@62_poly-right##33 S1#31pmos@62_poly-right##34 9.89
R1006 S1#31pmos@62_poly-right##34 S1#31pmos@62_poly-right##35 9.89
R1007 S1#31pmos@62_poly-right##35 S1#31pmos@62_poly-right##36 9.89
R1008 S1#31pmos@62_poly-right##36 S1#31pmos@62_poly-right##37 9.89
R1009 S1#31pmos@62_poly-right##37 S1#31pmos@62_poly-right##38 9.89
R1010 S1#31pmos@62_poly-right##38 S1#31pmos@62_poly-right##39 9.89
R1011 S1#31pmos@62_poly-right##39 S1#31pmos@62_poly-right##40 9.89
R1012 S1#31pmos@62_poly-right##40 S1#31pmos@62_poly-right##41 9.89
R1013 S1#31pmos@62_poly-right##41 S1#31pmos@62_poly-right##42 9.89
R1014 S1#31pmos@62_poly-right##42 S1#31pmos@62_poly-right##43 9.89
R1015 S1#31pmos@62_poly-right##43 S1#31pmos@62_poly-right##44 9.89
R1016 S1#31pmos@62_poly-right##44 S1#31pmos@62_poly-right##45 9.89
R1017 S1#31pmos@62_poly-right##45 S1#31pmos@62_poly-right##46 9.89
R1018 S1#31pmos@62_poly-right##46 S1#31pmos@62_poly-right##47 9.89
R1019 S1#31pmos@62_poly-right##47 S1#31pmos@62_poly-right##48 9.89
R1020 S1#31pmos@62_poly-right##48 S1#31pmos@62_poly-right##49 9.89
R1021 S1#31pmos@62_poly-right##49 S1#31pmos@62_poly-right##50 9.89
R1022 S1#31pmos@62_poly-right##50 S1#31pmos@62_poly-right##51 9.89
R1023 S1#31pmos@62_poly-right##51 S1#31pmos@62_poly-right##52 9.89
R1024 S1#31pmos@62_poly-right##52 S1#31pmos@62_poly-right##53 9.89
R1025 S1#31pmos@62_poly-right##53 S1#31pmos@62_poly-right##54 9.89
R1026 S1#31pmos@62_poly-right##54 S1#31pmos@62_poly-right##55 9.89
R1027 S1#31pmos@62_poly-right##55 S1#31pmos@62_poly-right##56 9.89
R1028 S1#31pmos@62_poly-right##56 S1#31pmos@62_poly-right##57 9.89
R1029 S1#31pmos@62_poly-right##57 S1#31pmos@62_poly-right##58 9.89
R1030 S1#31pmos@62_poly-right##58 S1#31pmos@62_poly-right##59 9.89
R1031 S1#31pmos@62_poly-right##59 S1#31pmos@62_poly-right##60 9.89
R1032 S1#31pmos@62_poly-right##60 S1#31pmos@62_poly-right##61 9.89
R1033 S1#31pmos@62_poly-right##61 S1#32pin@434_polysilicon-1 9.89
R1034 S1#32pin@434_polysilicon-1 S1#26pin@432_polysilicon-1 7.75
R1035 S1#29contact@504_metal-1-metal-2 S1#29contact@504_metal-1-metal-2##0 5.425
R1036 S1#29contact@504_metal-1-metal-2##0 S1#32pin@434_polysilicon-1 5.425
R1037 net@1276#7pmos@59_poly-left net@1276#7pmos@59_poly-left##0 9.688
R1038 net@1276#7pmos@59_poly-left##0 net@1276#7pmos@59_poly-left##1 9.688
R1039 net@1276#7pmos@59_poly-left##1 net@1276#7pmos@59_poly-left##2 9.688
R1040 net@1276#7pmos@59_poly-left##2 net@1276#8pin@441_polysilicon-1 9.688
R1041 net@1276#8pin@441_polysilicon-1 net@1276#8pin@441_polysilicon-1##0 9.946
R1042 net@1276#8pin@441_polysilicon-1##0 net@1276#8pin@441_polysilicon-1##1 9.946
R1043 net@1276#8pin@441_polysilicon-1##1 net@1276#8pin@441_polysilicon-1##2 9.946
R1044 net@1276#8pin@441_polysilicon-1##2 net@1276#8pin@441_polysilicon-1##3 9.946
R1045 net@1276#8pin@441_polysilicon-1##3 net@1276#8pin@441_polysilicon-1##4 9.946
R1046 net@1276#8pin@441_polysilicon-1##4 net@1276#8pin@441_polysilicon-1##5 9.946
R1047 net@1276#8pin@441_polysilicon-1##5 net@1276#8pin@441_polysilicon-1##6 9.946
R1048 net@1276#8pin@441_polysilicon-1##6 net@1276#8pin@441_polysilicon-1##7 9.946
R1049 net@1276#8pin@441_polysilicon-1##7 net@1276#8pin@441_polysilicon-1##8 9.946
R1050 net@1276#8pin@441_polysilicon-1##8 net@1276#8pin@441_polysilicon-1##9 9.946
R1051 net@1276#8pin@441_polysilicon-1##9 net@1276#8pin@441_polysilicon-1##10 9.946
R1052 net@1276#8pin@441_polysilicon-1##10 net@1276#9pin@442_polysilicon-1 9.946
R1053 S0#46nmos@59_poly-left S0#46nmos@59_poly-left##0 9.688
R1054 S0#46nmos@59_poly-left##0 S0#46nmos@59_poly-left##1 9.688
R1055 S0#46nmos@59_poly-left##1 S0#46nmos@59_poly-left##2 9.688
R1056 S0#46nmos@59_poly-left##2 S0#47pin@443_polysilicon-1 9.688
R1057 S0#36contact@494_metal-1-metal-2 S0#36contact@494_metal-1-metal-2##0 9.429
R1058 S0#36contact@494_metal-1-metal-2##0 S0#36contact@494_metal-1-metal-2##1 9.429
R1059 S0#36contact@494_metal-1-metal-2##1 S0#36contact@494_metal-1-metal-2##2 9.429
R1060 S0#36contact@494_metal-1-metal-2##2 S0#36contact@494_metal-1-metal-2##3 9.429
R1061 S0#36contact@494_metal-1-metal-2##3 S0#36contact@494_metal-1-metal-2##4 9.429
R1062 S0#36contact@494_metal-1-metal-2##4 S0#36contact@494_metal-1-metal-2##5 9.429
R1063 S0#36contact@494_metal-1-metal-2##5 S0#36contact@494_metal-1-metal-2##6 9.429
R1064 S0#36contact@494_metal-1-metal-2##6 S0#36contact@494_metal-1-metal-2##7 9.429
R1065 S0#36contact@494_metal-1-metal-2##7 S0#36contact@494_metal-1-metal-2##8 9.429
R1066 S0#36contact@494_metal-1-metal-2##8 S0#36contact@494_metal-1-metal-2##9 9.429
R1067 S0#36contact@494_metal-1-metal-2##9 S0#36contact@494_metal-1-metal-2##10 9.429
R1068 S0#36contact@494_metal-1-metal-2##10 S0#46nmos@59_poly-left 9.429
R1069 net@1276#11pin@446_polysilicon-1 net@1276#11pin@446_polysilicon-1##0 5.425
R1070 net@1276#11pin@446_polysilicon-1##0 net@1276#9pin@442_polysilicon-1 5.425
R1071 net@1276#12nmos@58_poly-right net@1276#12nmos@58_poly-right##0 9.688
R1072 net@1276#12nmos@58_poly-right##0 net@1276#12nmos@58_poly-right##1 9.688
R1073 net@1276#12nmos@58_poly-right##1 net@1276#12nmos@58_poly-right##2 9.688
R1074 net@1276#12nmos@58_poly-right##2 net@1276#11pin@446_polysilicon-1 9.688
R1075 S0#42pin@424_polysilicon-1 S0#42pin@424_polysilicon-1##0 9.521
R1076 S0#42pin@424_polysilicon-1##0 S0#42pin@424_polysilicon-1##1 9.521
R1077 S0#42pin@424_polysilicon-1##1 S0#42pin@424_polysilicon-1##2 9.521
R1078 S0#42pin@424_polysilicon-1##2 S0#42pin@424_polysilicon-1##3 9.521
R1079 S0#42pin@424_polysilicon-1##3 S0#42pin@424_polysilicon-1##4 9.521
R1080 S0#42pin@424_polysilicon-1##4 S0#42pin@424_polysilicon-1##5 9.521
R1081 S0#42pin@424_polysilicon-1##5 S0#48pin@447_polysilicon-1 9.521
R1082 S0#48pin@447_polysilicon-1 S0#48pin@447_polysilicon-1##0 9.868
R1083 S0#48pin@447_polysilicon-1##0 S0#48pin@447_polysilicon-1##1 9.868
R1084 S0#48pin@447_polysilicon-1##1 S0#48pin@447_polysilicon-1##2 9.868
R1085 S0#48pin@447_polysilicon-1##2 S0#48pin@447_polysilicon-1##3 9.868
R1086 S0#48pin@447_polysilicon-1##3 S0#48pin@447_polysilicon-1##4 9.868
R1087 S0#48pin@447_polysilicon-1##4 S0#48pin@447_polysilicon-1##5 9.868
R1088 S0#48pin@447_polysilicon-1##5 S0#48pin@447_polysilicon-1##6 9.868
R1089 S0#48pin@447_polysilicon-1##6 S0#48pin@447_polysilicon-1##7 9.868
R1090 S0#48pin@447_polysilicon-1##7 S0#48pin@447_polysilicon-1##8 9.868
R1091 S0#48pin@447_polysilicon-1##8 S0#48pin@447_polysilicon-1##9 9.868
R1092 S0#48pin@447_polysilicon-1##9 S0#48pin@447_polysilicon-1##10 9.868
R1093 S0#48pin@447_polysilicon-1##10 S0#48pin@447_polysilicon-1##11 9.868
R1094 S0#48pin@447_polysilicon-1##11 S0#48pin@447_polysilicon-1##12 9.868
R1095 S0#48pin@447_polysilicon-1##12 S0#48pin@447_polysilicon-1##13 9.868
R1096 S0#48pin@447_polysilicon-1##13 S0#48pin@447_polysilicon-1##14 9.868
R1097 S0#48pin@447_polysilicon-1##14 S0#48pin@447_polysilicon-1##15 9.868
R1098 S0#48pin@447_polysilicon-1##15 S0#48pin@447_polysilicon-1##16 9.868
R1099 S0#48pin@447_polysilicon-1##16 S0#48pin@447_polysilicon-1##17 9.868
R1100 S0#48pin@447_polysilicon-1##17 S0#48pin@447_polysilicon-1##18 9.868
R1101 S0#48pin@447_polysilicon-1##18 S0#48pin@447_polysilicon-1##19 9.868
R1102 S0#48pin@447_polysilicon-1##19 S0#48pin@447_polysilicon-1##20 9.868
R1103 S0#48pin@447_polysilicon-1##20 S0#48pin@447_polysilicon-1##21 9.868
R1104 S0#48pin@447_polysilicon-1##21 S0#48pin@447_polysilicon-1##22 9.868
R1105 S0#48pin@447_polysilicon-1##22 S0#48pin@447_polysilicon-1##23 9.868
R1106 S0#48pin@447_polysilicon-1##23 S0#48pin@447_polysilicon-1##24 9.868
R1107 S0#48pin@447_polysilicon-1##24 S0#48pin@447_polysilicon-1##25 9.868
R1108 S0#48pin@447_polysilicon-1##25 S0#48pin@447_polysilicon-1##26 9.868
R1109 S0#48pin@447_polysilicon-1##26 S0#48pin@447_polysilicon-1##27 9.868
R1110 S0#48pin@447_polysilicon-1##27 S0#48pin@447_polysilicon-1##28 9.868
R1111 S0#48pin@447_polysilicon-1##28 S0#47pin@443_polysilicon-1 9.868
R1112 S0#49pmos@58_poly-left S0#49pmos@58_poly-left##0 9.688
R1113 S0#49pmos@58_poly-left##0 S0#49pmos@58_poly-left##1 9.688
R1114 S0#49pmos@58_poly-left##1 S0#49pmos@58_poly-left##2 9.688
R1115 S0#49pmos@58_poly-left##2 S0#48pin@447_polysilicon-1 9.688
R1116 net@1327 net@1327 0
R1117 S0#50pin@423_polysilicon-1 S0#50pin@423_polysilicon-1##0 9.972
R1118 S0#50pin@423_polysilicon-1##0 S0#50pin@423_polysilicon-1##1 9.972
R1119 S0#50pin@423_polysilicon-1##1 S0#50pin@423_polysilicon-1##2 9.972
R1120 S0#50pin@423_polysilicon-1##2 S0#50pin@423_polysilicon-1##3 9.972
R1121 S0#50pin@423_polysilicon-1##3 S0#50pin@423_polysilicon-1##4 9.972
R1122 S0#50pin@423_polysilicon-1##4 S0#50pin@423_polysilicon-1##5 9.972
R1123 S0#50pin@423_polysilicon-1##5 S0#50pin@423_polysilicon-1##6 9.972
R1124 S0#50pin@423_polysilicon-1##6 S0#50pin@423_polysilicon-1##7 9.972
R1125 S0#50pin@423_polysilicon-1##7 S0#50pin@423_polysilicon-1##8 9.972
R1126 S0#50pin@423_polysilicon-1##8 S0#50pin@423_polysilicon-1##9 9.972
R1127 S0#50pin@423_polysilicon-1##9 S0#50pin@423_polysilicon-1##10 9.972
R1128 S0#50pin@423_polysilicon-1##10 S0#50pin@423_polysilicon-1##11 9.972
R1129 S0#50pin@423_polysilicon-1##11 S0#50pin@423_polysilicon-1##12 9.972
R1130 S0#50pin@423_polysilicon-1##12 S0#50pin@423_polysilicon-1##13 9.972
R1131 S0#50pin@423_polysilicon-1##13 S0#50pin@423_polysilicon-1##14 9.972
R1132 S0#50pin@423_polysilicon-1##14 S0#50pin@423_polysilicon-1##15 9.972
R1133 S0#50pin@423_polysilicon-1##15 S0#50pin@423_polysilicon-1##16 9.972
R1134 S0#50pin@423_polysilicon-1##16 S0#50pin@423_polysilicon-1##17 9.972
R1135 S0#50pin@423_polysilicon-1##17 S0#50pin@423_polysilicon-1##18 9.972
R1136 S0#50pin@423_polysilicon-1##18 S0#50pin@423_polysilicon-1##19 9.972
R1137 S0#50pin@423_polysilicon-1##19 S0#50pin@423_polysilicon-1##20 9.972
R1138 S0#50pin@423_polysilicon-1##20 S0#50pin@423_polysilicon-1##21 9.972
R1139 S0#50pin@423_polysilicon-1##21 S0#50pin@423_polysilicon-1##22 9.972
R1140 S0#50pin@423_polysilicon-1##22 S0#50pin@423_polysilicon-1##23 9.972
R1141 S0#50pin@423_polysilicon-1##23 S0#50pin@423_polysilicon-1##24 9.972
R1142 S0#50pin@423_polysilicon-1##24 S0#50pin@423_polysilicon-1##25 9.972
R1143 S0#50pin@423_polysilicon-1##25 S0#50pin@423_polysilicon-1##26 9.972
R1144 S0#50pin@423_polysilicon-1##26 S0#50pin@423_polysilicon-1##27 9.972
R1145 S0#50pin@423_polysilicon-1##27 S0#50pin@423_polysilicon-1##28 9.972
R1146 S0#50pin@423_polysilicon-1##28 S0#42pin@424_polysilicon-1 9.972
R1147 S0#52nmos@65_poly-left S0#52nmos@65_poly-left##0 9.688
R1148 S0#52nmos@65_poly-left##0 S0#52nmos@65_poly-left##1 9.688
R1149 S0#52nmos@65_poly-left##1 S0#52nmos@65_poly-left##2 9.688
R1150 S0#52nmos@65_poly-left##2 S0#53pin@507_polysilicon-1 9.688
R1151 net@1360 net@1360##0 9.858
R1152 net@1360##0 net@1360##1 9.858
R1153 net@1360##1 net@1360##2 9.858
R1154 net@1360##2 net@1360##3 9.858
R1155 net@1360##3 net@1360##4 9.858
R1156 net@1360##4 net@1360##5 9.858
R1157 net@1360##5 net@1360##6 9.858
R1158 net@1360##6 net@1360##7 9.858
R1159 net@1360##7 net@1360##8 9.858
R1160 net@1360##8 net@1360##9 9.858
R1161 net@1360##9 net@1360##10 9.858
R1162 net@1360##10 net@1360##11 9.858
R1163 net@1360##11 net@1360##12 9.858
R1164 net@1360##12 net@1360##13 9.858
R1165 net@1360##13 net@1360##14 9.858
R1166 net@1360##14 net@1360##15 9.858
R1167 net@1360##15 net@1360##16 9.858
R1168 net@1360##16 net@1360##17 9.858
R1169 net@1360##17 net@1360##18 9.858
R1170 net@1360##18 net@1360##19 9.858
R1171 net@1360##19 net@1360##20 9.858
R1172 net@1360##20 net@1360##21 9.858
R1173 net@1360##21 net@1360##22 9.858
R1174 net@1360##22 net@1360##23 9.858
R1175 net@1360##23 net@1360#1pin@504_polysilicon-1 9.858
R1176 net@1360#2pmos@65_poly-left net@1360#2pmos@65_poly-left##0 9.688
R1177 net@1360#2pmos@65_poly-left##0 net@1360#2pmos@65_poly-left##1 9.688
R1178 net@1360#2pmos@65_poly-left##1 net@1360#2pmos@65_poly-left##2 9.688
R1179 net@1360#2pmos@65_poly-left##2 net@1360 9.688
R1180 net@1360#3nmos@64_poly-left net@1360#3nmos@64_poly-left##0 9.688
R1181 net@1360#3nmos@64_poly-left##0 net@1360#3nmos@64_poly-left##1 9.688
R1182 net@1360#3nmos@64_poly-left##1 net@1360#3nmos@64_poly-left##2 9.688
R1183 net@1360#3nmos@64_poly-left##2 net@1360#4pin@509_polysilicon-1 9.688
R1184 net@1360 net@1360##0 9.743
R1185 net@1360##0 net@1360##1 9.743
R1186 net@1360##1 net@1360##2 9.743
R1187 net@1360##2 net@1360##3 9.743
R1188 net@1360##3 net@1360##4 9.743
R1189 net@1360##4 net@1360##5 9.743
R1190 net@1360##5 net@1360#4pin@509_polysilicon-1 9.743
R1191 net@1360#5contact@564_metal-1-metal-2 net@1360#5contact@564_metal-1-metal-2##0 9.3
R1192 net@1360#5contact@564_metal-1-metal-2##0 net@1360#5contact@564_metal-1-metal-2##1 9.3
R1193 net@1360#5contact@564_metal-1-metal-2##1 net@1360#5contact@564_metal-1-metal-2##2 9.3
R1194 net@1360#5contact@564_metal-1-metal-2##2 net@1360#5contact@564_metal-1-metal-2##3 9.3
R1195 net@1360#5contact@564_metal-1-metal-2##3 net@1360#5contact@564_metal-1-metal-2##4 9.3
R1196 net@1360#5contact@564_metal-1-metal-2##4 net@1360#5contact@564_metal-1-metal-2##5 9.3
R1197 net@1360#5contact@564_metal-1-metal-2##5 net@1360#5contact@564_metal-1-metal-2##6 9.3
R1198 net@1360#5contact@564_metal-1-metal-2##6 net@1360#4pin@509_polysilicon-1 9.3
R1199 net@1381 net@1381##0 9.688
R1200 net@1381##0 net@1381##1 9.688
R1201 net@1381##1 net@1381##2 9.688
R1202 net@1381##2 net@1381#1pin@513_polysilicon-1 9.688
R1203 net@1382 net@1382 0
R1204 net@1381#2pmos@69_poly-left net@1381#2pmos@69_poly-left##0 9.688
R1205 net@1381#2pmos@69_poly-left##0 net@1381#2pmos@69_poly-left##1 9.688
R1206 net@1381#2pmos@69_poly-left##1 net@1381#2pmos@69_poly-left##2 9.688
R1207 net@1381#2pmos@69_poly-left##2 net@1381#3pin@514_polysilicon-1 9.688
R1208 net@1381#3pin@514_polysilicon-1 net@1381#3pin@514_polysilicon-1##0 9.92
R1209 net@1381#3pin@514_polysilicon-1##0 net@1381#3pin@514_polysilicon-1##1 9.92
R1210 net@1381#3pin@514_polysilicon-1##1 net@1381#3pin@514_polysilicon-1##2 9.92
R1211 net@1381#3pin@514_polysilicon-1##2 net@1381#3pin@514_polysilicon-1##3 9.92
R1212 net@1381#3pin@514_polysilicon-1##3 net@1381#6pin@516_polysilicon-1 9.92
R1213 net@1381#6pin@516_polysilicon-1 net@1381#6pin@516_polysilicon-1##0 9.3
R1214 net@1381#6pin@516_polysilicon-1##0 net@1381#6pin@516_polysilicon-1##1 9.3
R1215 net@1381#6pin@516_polysilicon-1##1 net@1381#6pin@516_polysilicon-1##2 9.3
R1216 net@1381#6pin@516_polysilicon-1##2 net@1381#6pin@516_polysilicon-1##3 9.3
R1217 net@1381#6pin@516_polysilicon-1##3 net@1381#6pin@516_polysilicon-1##4 9.3
R1218 net@1381#6pin@516_polysilicon-1##4 net@1381#1pin@513_polysilicon-1 9.3
R1219 net@1381#4contact@566_metal-1-metal-2 net@1381#4contact@566_metal-1-metal-2##0 5.425
R1220 net@1381#4contact@566_metal-1-metal-2##0 net@1381#6pin@516_polysilicon-1 5.425
R1221 S1#34pin@480_polysilicon-1 S1#34pin@480_polysilicon-1##0 9.652
R1222 S1#34pin@480_polysilicon-1##0 S1#34pin@480_polysilicon-1##1 9.652
R1223 S1#34pin@480_polysilicon-1##1 S1#34pin@480_polysilicon-1##2 9.652
R1224 S1#34pin@480_polysilicon-1##2 S1#34pin@480_polysilicon-1##3 9.652
R1225 S1#34pin@480_polysilicon-1##3 S1#34pin@480_polysilicon-1##4 9.652
R1226 S1#34pin@480_polysilicon-1##4 S1#34pin@480_polysilicon-1##5 9.652
R1227 S1#34pin@480_polysilicon-1##5 S1#34pin@480_polysilicon-1##6 9.652
R1228 S1#34pin@480_polysilicon-1##6 S1#34pin@480_polysilicon-1##7 9.652
R1229 S1#34pin@480_polysilicon-1##7 S1#34pin@480_polysilicon-1##8 9.652
R1230 S1#34pin@480_polysilicon-1##8 S1#34pin@480_polysilicon-1##9 9.652
R1231 S1#34pin@480_polysilicon-1##9 S1#34pin@480_polysilicon-1##10 9.652
R1232 S1#34pin@480_polysilicon-1##10 S1#34pin@480_polysilicon-1##11 9.652
R1233 S1#34pin@480_polysilicon-1##11 S1#34pin@480_polysilicon-1##12 9.652
R1234 S1#34pin@480_polysilicon-1##12 S1#34pin@480_polysilicon-1##13 9.652
R1235 S1#34pin@480_polysilicon-1##13 S1#34pin@480_polysilicon-1##14 9.652
R1236 S1#34pin@480_polysilicon-1##14 S1#34pin@480_polysilicon-1##15 9.652
R1237 S1#34pin@480_polysilicon-1##15 S1#34pin@480_polysilicon-1##16 9.652
R1238 S1#34pin@480_polysilicon-1##16 S1#34pin@480_polysilicon-1##17 9.652
R1239 S1#34pin@480_polysilicon-1##17 S1#34pin@480_polysilicon-1##18 9.652
R1240 S1#34pin@480_polysilicon-1##18 S1#34pin@480_polysilicon-1##19 9.652
R1241 S1#34pin@480_polysilicon-1##19 S1#34pin@480_polysilicon-1##20 9.652
R1242 S1#34pin@480_polysilicon-1##20 S1#35pin@517_polysilicon-1 9.652
R1243 S1#36pin@489_polysilicon-1 S1#36pin@489_polysilicon-1##0 9.61
R1244 S1#36pin@489_polysilicon-1##0 S1#36pin@489_polysilicon-1##1 9.61
R1245 S1#36pin@489_polysilicon-1##1 S1#36pin@489_polysilicon-1##2 9.61
R1246 S1#36pin@489_polysilicon-1##2 S1#36pin@489_polysilicon-1##3 9.61
R1247 S1#36pin@489_polysilicon-1##3 S1#35pin@517_polysilicon-1 9.61
R1248 S1#37nmos@69_poly-left S1#37nmos@69_poly-left##0 9.688
R1249 S1#37nmos@69_poly-left##0 S1#37nmos@69_poly-left##1 9.688
R1250 S1#37nmos@69_poly-left##1 S1#37nmos@69_poly-left##2 9.688
R1251 S1#37nmos@69_poly-left##2 S1#34pin@480_polysilicon-1 9.688
R1252 net@1413 net@1413 0
R1253 net@1413 net@1413 0
R1254 S1#38pmos@68_poly-left S1#38pmos@68_poly-left##0 9.688
R1255 S1#38pmos@68_poly-left##0 S1#38pmos@68_poly-left##1 9.688
R1256 S1#38pmos@68_poly-left##1 S1#38pmos@68_poly-left##2 9.688
R1257 S1#38pmos@68_poly-left##2 S1#39pin@479_polysilicon-1 9.688
R1258 S1#39pin@479_polysilicon-1 S1#39pin@479_polysilicon-1##0 9.958
R1259 S1#39pin@479_polysilicon-1##0 S1#39pin@479_polysilicon-1##1 9.958
R1260 S1#39pin@479_polysilicon-1##1 S1#39pin@479_polysilicon-1##2 9.958
R1261 S1#39pin@479_polysilicon-1##2 S1#39pin@479_polysilicon-1##3 9.958
R1262 S1#39pin@479_polysilicon-1##3 S1#39pin@479_polysilicon-1##4 9.958
R1263 S1#39pin@479_polysilicon-1##4 S1#39pin@479_polysilicon-1##5 9.958
R1264 S1#39pin@479_polysilicon-1##5 S1#39pin@479_polysilicon-1##6 9.958
R1265 S1#39pin@479_polysilicon-1##6 S1#39pin@479_polysilicon-1##7 9.958
R1266 S1#39pin@479_polysilicon-1##7 S1#39pin@479_polysilicon-1##8 9.958
R1267 S1#39pin@479_polysilicon-1##8 S1#39pin@479_polysilicon-1##9 9.958
R1268 S1#39pin@479_polysilicon-1##9 S1#39pin@479_polysilicon-1##10 9.958
R1269 S1#39pin@479_polysilicon-1##10 S1#39pin@479_polysilicon-1##11 9.958
R1270 S1#39pin@479_polysilicon-1##11 S1#39pin@479_polysilicon-1##12 9.958
R1271 S1#39pin@479_polysilicon-1##12 S1#39pin@479_polysilicon-1##13 9.958
R1272 S1#39pin@479_polysilicon-1##13 S1#39pin@479_polysilicon-1##14 9.958
R1273 S1#39pin@479_polysilicon-1##14 S1#39pin@479_polysilicon-1##15 9.958
R1274 S1#39pin@479_polysilicon-1##15 S1#39pin@479_polysilicon-1##16 9.958
R1275 S1#39pin@479_polysilicon-1##16 S1#39pin@479_polysilicon-1##17 9.958
R1276 S1#39pin@479_polysilicon-1##17 S1#39pin@479_polysilicon-1##18 9.958
R1277 S1#39pin@479_polysilicon-1##18 S1#39pin@479_polysilicon-1##19 9.958
R1278 S1#39pin@479_polysilicon-1##19 S1#39pin@479_polysilicon-1##20 9.958
R1279 S1#39pin@479_polysilicon-1##20 S1#39pin@479_polysilicon-1##21 9.958
R1280 S1#39pin@479_polysilicon-1##21 S1#39pin@479_polysilicon-1##22 9.958
R1281 S1#39pin@479_polysilicon-1##22 S1#39pin@479_polysilicon-1##23 9.958
R1282 S1#39pin@479_polysilicon-1##23 S1#39pin@479_polysilicon-1##24 9.958
R1283 S1#39pin@479_polysilicon-1##24 S1#39pin@479_polysilicon-1##25 9.958
R1284 S1#39pin@479_polysilicon-1##25 S1#39pin@479_polysilicon-1##26 9.958
R1285 S1#39pin@479_polysilicon-1##26 S1#39pin@479_polysilicon-1##27 9.958
R1286 S1#39pin@479_polysilicon-1##27 S1#39pin@479_polysilicon-1##28 9.958
R1287 S1#39pin@479_polysilicon-1##28 S1#39pin@479_polysilicon-1##29 9.958
R1288 S1#39pin@479_polysilicon-1##29 S1#39pin@479_polysilicon-1##30 9.958
R1289 S1#39pin@479_polysilicon-1##30 S1#39pin@479_polysilicon-1##31 9.958
R1290 S1#39pin@479_polysilicon-1##31 S1#34pin@480_polysilicon-1 9.958
R1291 S0#54pmos@64_poly-left S0#54pmos@64_poly-left##0 9.688
R1292 S0#54pmos@64_poly-left##0 S0#54pmos@64_poly-left##1 9.688
R1293 S0#54pmos@64_poly-left##1 S0#54pmos@64_poly-left##2 9.688
R1294 S0#54pmos@64_poly-left##2 S0#55pin@481_polysilicon-1 9.688
R1295 net@1414 net@1414 0
R1296 net@1381#4contact@566_metal-1-metal-2 net@1381#4contact@566_metal-1-metal-2 0
R1297 net@1360#10contact@558_metal-1-n-act net@1360#10contact@558_metal-1-n-act 0
R1298 S0#58pmos@71_poly-right S0#58pmos@71_poly-right##0 9.937
R1299 S0#58pmos@71_poly-right##0 S0#58pmos@71_poly-right##1 9.937
R1300 S0#58pmos@71_poly-right##1 S0#58pmos@71_poly-right##2 9.937
R1301 S0#58pmos@71_poly-right##2 S0#58pmos@71_poly-right##3 9.937
R1302 S0#58pmos@71_poly-right##3 S0#58pmos@71_poly-right##4 9.937
R1303 S0#58pmos@71_poly-right##4 S0#58pmos@71_poly-right##5 9.937
R1304 S0#58pmos@71_poly-right##5 S0#58pmos@71_poly-right##6 9.937
R1305 S0#58pmos@71_poly-right##6 S0#58pmos@71_poly-right##7 9.937
R1306 S0#58pmos@71_poly-right##7 S0#58pmos@71_poly-right##8 9.937
R1307 S0#58pmos@71_poly-right##8 S0#58pmos@71_poly-right##9 9.937
R1308 S0#58pmos@71_poly-right##9 S0#58pmos@71_poly-right##10 9.937
R1309 S0#58pmos@71_poly-right##10 S0#58pmos@71_poly-right##11 9.937
R1310 S0#58pmos@71_poly-right##11 S0#58pmos@71_poly-right##12 9.937
R1311 S0#58pmos@71_poly-right##12 S0#58pmos@71_poly-right##13 9.937
R1312 S0#58pmos@71_poly-right##13 S0#58pmos@71_poly-right##14 9.937
R1313 S0#58pmos@71_poly-right##14 S0#58pmos@71_poly-right##15 9.937
R1314 S0#58pmos@71_poly-right##15 S0#58pmos@71_poly-right##16 9.937
R1315 S0#58pmos@71_poly-right##16 S0#58pmos@71_poly-right##17 9.937
R1316 S0#58pmos@71_poly-right##17 S0#58pmos@71_poly-right##18 9.937
R1317 S0#58pmos@71_poly-right##18 S0#58pmos@71_poly-right##19 9.937
R1318 S0#58pmos@71_poly-right##19 S0#58pmos@71_poly-right##20 9.937
R1319 S0#58pmos@71_poly-right##20 S0#58pmos@71_poly-right##21 9.937
R1320 S0#58pmos@71_poly-right##21 S0#58pmos@71_poly-right##22 9.937
R1321 S0#58pmos@71_poly-right##22 S0#58pmos@71_poly-right##23 9.937
R1322 S0#58pmos@71_poly-right##23 S0#58pmos@71_poly-right##24 9.937
R1323 S0#58pmos@71_poly-right##24 S0#58pmos@71_poly-right##25 9.937
R1324 S0#58pmos@71_poly-right##25 S0#58pmos@71_poly-right##26 9.937
R1325 S0#58pmos@71_poly-right##26 S0#58pmos@71_poly-right##27 9.937
R1326 S0#58pmos@71_poly-right##27 S0#58pmos@71_poly-right##28 9.937
R1327 S0#58pmos@71_poly-right##28 S0#58pmos@71_poly-right##29 9.937
R1328 S0#58pmos@71_poly-right##29 S0#58pmos@71_poly-right##30 9.937
R1329 S0#58pmos@71_poly-right##30 S0#58pmos@71_poly-right##31 9.937
R1330 S0#58pmos@71_poly-right##31 S0#58pmos@71_poly-right##32 9.937
R1331 S0#58pmos@71_poly-right##32 S0#58pmos@71_poly-right##33 9.937
R1332 S0#58pmos@71_poly-right##33 S0#58pmos@71_poly-right##34 9.937
R1333 S0#58pmos@71_poly-right##34 S0#58pmos@71_poly-right##35 9.937
R1334 S0#58pmos@71_poly-right##35 S0#58pmos@71_poly-right##36 9.937
R1335 S0#58pmos@71_poly-right##36 S0#58pmos@71_poly-right##37 9.937
R1336 S0#58pmos@71_poly-right##37 S0#58pmos@71_poly-right##38 9.937
R1337 S0#58pmos@71_poly-right##38 S0#58pmos@71_poly-right##39 9.937
R1338 S0#58pmos@71_poly-right##39 S0#58pmos@71_poly-right##40 9.937
R1339 S0#58pmos@71_poly-right##40 S0#58pmos@71_poly-right##41 9.937
R1340 S0#58pmos@71_poly-right##41 S0#58pmos@71_poly-right##42 9.937
R1341 S0#58pmos@71_poly-right##42 S0#58pmos@71_poly-right##43 9.937
R1342 S0#58pmos@71_poly-right##43 S0#58pmos@71_poly-right##44 9.937
R1343 S0#58pmos@71_poly-right##44 S0#58pmos@71_poly-right##45 9.937
R1344 S0#58pmos@71_poly-right##45 S0#58pmos@71_poly-right##46 9.937
R1345 S0#58pmos@71_poly-right##46 S0#58pmos@71_poly-right##47 9.937
R1346 S0#58pmos@71_poly-right##47 S0#58pmos@71_poly-right##48 9.937
R1347 S0#58pmos@71_poly-right##48 S0#58pmos@71_poly-right##49 9.937
R1348 S0#58pmos@71_poly-right##49 S0#58pmos@71_poly-right##50 9.937
R1349 S0#58pmos@71_poly-right##50 S0#58pmos@71_poly-right##51 9.937
R1350 S0#58pmos@71_poly-right##51 S0#58pmos@71_poly-right##52 9.937
R1351 S0#58pmos@71_poly-right##52 S0#58pmos@71_poly-right##53 9.937
R1352 S0#58pmos@71_poly-right##53 S0#58pmos@71_poly-right##54 9.937
R1353 S0#58pmos@71_poly-right##54 S0#59pin@486_polysilicon-1 9.937
R1354 S0#59pin@486_polysilicon-1 S0#59pin@486_polysilicon-1##0 9.688
R1355 S0#59pin@486_polysilicon-1##0 S0#59pin@486_polysilicon-1##1 9.688
R1356 S0#59pin@486_polysilicon-1##1 S0#59pin@486_polysilicon-1##2 9.688
R1357 S0#59pin@486_polysilicon-1##2 S0#59pin@486_polysilicon-1##3 9.688
R1358 S0#59pin@486_polysilicon-1##3 S0#59pin@486_polysilicon-1##4 9.688
R1359 S0#59pin@486_polysilicon-1##4 S0#59pin@486_polysilicon-1##5 9.688
R1360 S0#59pin@486_polysilicon-1##5 S0#59pin@486_polysilicon-1##6 9.688
R1361 S0#59pin@486_polysilicon-1##6 S0#60nmos@71_poly-right 9.688
R1362 net@1414 net@1414 0
R1363 S0 S0##0 9.723
R1364 S0##0 S0##1 9.723
R1365 S0##1 S0##2 9.723
R1366 S0##2 S0##3 9.723
R1367 S0##3 S0##4 9.723
R1368 S0##4 S0##5 9.723
R1369 S0##5 S0##6 9.723
R1370 S0##6 S0##7 9.723
R1371 S0##7 S0##8 9.723
R1372 S0##8 S0##9 9.723
R1373 S0##9 S0#59pin@486_polysilicon-1 9.723
R1374 net@1360#5contact@564_metal-1-metal-2 net@1360#10contact@558_metal-1-n-act 4.927
R1375 S1#36pin@489_polysilicon-1 S1#36pin@489_polysilicon-1##0 9.688
R1376 S1#36pin@489_polysilicon-1##0 S1#36pin@489_polysilicon-1##1 9.688
R1377 S1#36pin@489_polysilicon-1##1 S1#36pin@489_polysilicon-1##2 9.688
R1378 S1#36pin@489_polysilicon-1##2 S1#36pin@489_polysilicon-1##3 9.688
R1379 S1#36pin@489_polysilicon-1##3 S1#36pin@489_polysilicon-1##4 9.688
R1380 S1#36pin@489_polysilicon-1##4 S1#36pin@489_polysilicon-1##5 9.688
R1381 S1#36pin@489_polysilicon-1##5 S1#36pin@489_polysilicon-1##6 9.688
R1382 S1#36pin@489_polysilicon-1##6 S1#36pin@489_polysilicon-1##7 9.688
R1383 S1#36pin@489_polysilicon-1##7 S1#36pin@489_polysilicon-1##8 9.688
R1384 S1#36pin@489_polysilicon-1##8 S1#36pin@489_polysilicon-1##9 9.688
R1385 S1#36pin@489_polysilicon-1##9 S1#36pin@489_polysilicon-1##10 9.688
R1386 S1#36pin@489_polysilicon-1##10 S1#36pin@489_polysilicon-1##11 9.688
R1387 S1#36pin@489_polysilicon-1##11 S1#36pin@489_polysilicon-1##12 9.688
R1388 S1#36pin@489_polysilicon-1##12 S1#36pin@489_polysilicon-1##13 9.688
R1389 S1#36pin@489_polysilicon-1##13 S1#36pin@489_polysilicon-1##14 9.688
R1390 S1#36pin@489_polysilicon-1##14 S1#36pin@489_polysilicon-1##15 9.688
R1391 S1#36pin@489_polysilicon-1##15 S1#36pin@489_polysilicon-1##16 9.688
R1392 S1#36pin@489_polysilicon-1##16 S1#36pin@489_polysilicon-1##17 9.688
R1393 S1#36pin@489_polysilicon-1##17 S1#36pin@489_polysilicon-1##18 9.688
R1394 S1#36pin@489_polysilicon-1##18 S1#36pin@489_polysilicon-1##19 9.688
R1395 S1#36pin@489_polysilicon-1##19 S1#36pin@489_polysilicon-1##20 9.688
R1396 S1#36pin@489_polysilicon-1##20 S1#36pin@489_polysilicon-1##21 9.688
R1397 S1#36pin@489_polysilicon-1##21 S1#36pin@489_polysilicon-1##22 9.688
R1398 S1#36pin@489_polysilicon-1##22 S1#36pin@489_polysilicon-1##23 9.688
R1399 S1#36pin@489_polysilicon-1##23 S1#36pin@489_polysilicon-1##24 9.688
R1400 S1#36pin@489_polysilicon-1##24 S1#36pin@489_polysilicon-1##25 9.688
R1401 S1#36pin@489_polysilicon-1##25 S1#36pin@489_polysilicon-1##26 9.688
R1402 S1#36pin@489_polysilicon-1##26 S1#40pin@490_polysilicon-1 9.688
R1403 S1#44pmos@70_poly-right S1#44pmos@70_poly-right##0 9.89
R1404 S1#44pmos@70_poly-right##0 S1#44pmos@70_poly-right##1 9.89
R1405 S1#44pmos@70_poly-right##1 S1#44pmos@70_poly-right##2 9.89
R1406 S1#44pmos@70_poly-right##2 S1#44pmos@70_poly-right##3 9.89
R1407 S1#44pmos@70_poly-right##3 S1#44pmos@70_poly-right##4 9.89
R1408 S1#44pmos@70_poly-right##4 S1#44pmos@70_poly-right##5 9.89
R1409 S1#44pmos@70_poly-right##5 S1#44pmos@70_poly-right##6 9.89
R1410 S1#44pmos@70_poly-right##6 S1#44pmos@70_poly-right##7 9.89
R1411 S1#44pmos@70_poly-right##7 S1#44pmos@70_poly-right##8 9.89
R1412 S1#44pmos@70_poly-right##8 S1#44pmos@70_poly-right##9 9.89
R1413 S1#44pmos@70_poly-right##9 S1#44pmos@70_poly-right##10 9.89
R1414 S1#44pmos@70_poly-right##10 S1#44pmos@70_poly-right##11 9.89
R1415 S1#44pmos@70_poly-right##11 S1#44pmos@70_poly-right##12 9.89
R1416 S1#44pmos@70_poly-right##12 S1#44pmos@70_poly-right##13 9.89
R1417 S1#44pmos@70_poly-right##13 S1#44pmos@70_poly-right##14 9.89
R1418 S1#44pmos@70_poly-right##14 S1#44pmos@70_poly-right##15 9.89
R1419 S1#44pmos@70_poly-right##15 S1#44pmos@70_poly-right##16 9.89
R1420 S1#44pmos@70_poly-right##16 S1#44pmos@70_poly-right##17 9.89
R1421 S1#44pmos@70_poly-right##17 S1#44pmos@70_poly-right##18 9.89
R1422 S1#44pmos@70_poly-right##18 S1#44pmos@70_poly-right##19 9.89
R1423 S1#44pmos@70_poly-right##19 S1#44pmos@70_poly-right##20 9.89
R1424 S1#44pmos@70_poly-right##20 S1#44pmos@70_poly-right##21 9.89
R1425 S1#44pmos@70_poly-right##21 S1#44pmos@70_poly-right##22 9.89
R1426 S1#44pmos@70_poly-right##22 S1#44pmos@70_poly-right##23 9.89
R1427 S1#44pmos@70_poly-right##23 S1#44pmos@70_poly-right##24 9.89
R1428 S1#44pmos@70_poly-right##24 S1#44pmos@70_poly-right##25 9.89
R1429 S1#44pmos@70_poly-right##25 S1#44pmos@70_poly-right##26 9.89
R1430 S1#44pmos@70_poly-right##26 S1#44pmos@70_poly-right##27 9.89
R1431 S1#44pmos@70_poly-right##27 S1#44pmos@70_poly-right##28 9.89
R1432 S1#44pmos@70_poly-right##28 S1#44pmos@70_poly-right##29 9.89
R1433 S1#44pmos@70_poly-right##29 S1#44pmos@70_poly-right##30 9.89
R1434 S1#44pmos@70_poly-right##30 S1#44pmos@70_poly-right##31 9.89
R1435 S1#44pmos@70_poly-right##31 S1#44pmos@70_poly-right##32 9.89
R1436 S1#44pmos@70_poly-right##32 S1#44pmos@70_poly-right##33 9.89
R1437 S1#44pmos@70_poly-right##33 S1#44pmos@70_poly-right##34 9.89
R1438 S1#44pmos@70_poly-right##34 S1#44pmos@70_poly-right##35 9.89
R1439 S1#44pmos@70_poly-right##35 S1#44pmos@70_poly-right##36 9.89
R1440 S1#44pmos@70_poly-right##36 S1#44pmos@70_poly-right##37 9.89
R1441 S1#44pmos@70_poly-right##37 S1#44pmos@70_poly-right##38 9.89
R1442 S1#44pmos@70_poly-right##38 S1#44pmos@70_poly-right##39 9.89
R1443 S1#44pmos@70_poly-right##39 S1#44pmos@70_poly-right##40 9.89
R1444 S1#44pmos@70_poly-right##40 S1#44pmos@70_poly-right##41 9.89
R1445 S1#44pmos@70_poly-right##41 S1#44pmos@70_poly-right##42 9.89
R1446 S1#44pmos@70_poly-right##42 S1#44pmos@70_poly-right##43 9.89
R1447 S1#44pmos@70_poly-right##43 S1#44pmos@70_poly-right##44 9.89
R1448 S1#44pmos@70_poly-right##44 S1#44pmos@70_poly-right##45 9.89
R1449 S1#44pmos@70_poly-right##45 S1#44pmos@70_poly-right##46 9.89
R1450 S1#44pmos@70_poly-right##46 S1#44pmos@70_poly-right##47 9.89
R1451 S1#44pmos@70_poly-right##47 S1#44pmos@70_poly-right##48 9.89
R1452 S1#44pmos@70_poly-right##48 S1#44pmos@70_poly-right##49 9.89
R1453 S1#44pmos@70_poly-right##49 S1#44pmos@70_poly-right##50 9.89
R1454 S1#44pmos@70_poly-right##50 S1#44pmos@70_poly-right##51 9.89
R1455 S1#44pmos@70_poly-right##51 S1#44pmos@70_poly-right##52 9.89
R1456 S1#44pmos@70_poly-right##52 S1#44pmos@70_poly-right##53 9.89
R1457 S1#44pmos@70_poly-right##53 S1#44pmos@70_poly-right##54 9.89
R1458 S1#44pmos@70_poly-right##54 S1#44pmos@70_poly-right##55 9.89
R1459 S1#44pmos@70_poly-right##55 S1#44pmos@70_poly-right##56 9.89
R1460 S1#44pmos@70_poly-right##56 S1#44pmos@70_poly-right##57 9.89
R1461 S1#44pmos@70_poly-right##57 S1#44pmos@70_poly-right##58 9.89
R1462 S1#44pmos@70_poly-right##58 S1#44pmos@70_poly-right##59 9.89
R1463 S1#44pmos@70_poly-right##59 S1#44pmos@70_poly-right##60 9.89
R1464 S1#44pmos@70_poly-right##60 S1#44pmos@70_poly-right##61 9.89
R1465 S1#44pmos@70_poly-right##61 S1#45pin@492_polysilicon-1 9.89
R1466 S1#45pin@492_polysilicon-1 S1#40pin@490_polysilicon-1 7.75
R1467 S1 S1##0 5.425
R1468 S1##0 S1#45pin@492_polysilicon-1 5.425
R1469 net@1360#14pmos@67_poly-left net@1360#14pmos@67_poly-left##0 9.688
R1470 net@1360#14pmos@67_poly-left##0 net@1360#14pmos@67_poly-left##1 9.688
R1471 net@1360#14pmos@67_poly-left##1 net@1360#14pmos@67_poly-left##2 9.688
R1472 net@1360#14pmos@67_poly-left##2 net@1360#15pin@499_polysilicon-1 9.688
R1473 net@1360#15pin@499_polysilicon-1 net@1360#15pin@499_polysilicon-1##0 9.946
R1474 net@1360#15pin@499_polysilicon-1##0 net@1360#15pin@499_polysilicon-1##1 9.946
R1475 net@1360#15pin@499_polysilicon-1##1 net@1360#15pin@499_polysilicon-1##2 9.946
R1476 net@1360#15pin@499_polysilicon-1##2 net@1360#15pin@499_polysilicon-1##3 9.946
R1477 net@1360#15pin@499_polysilicon-1##3 net@1360#15pin@499_polysilicon-1##4 9.946
R1478 net@1360#15pin@499_polysilicon-1##4 net@1360#15pin@499_polysilicon-1##5 9.946
R1479 net@1360#15pin@499_polysilicon-1##5 net@1360#15pin@499_polysilicon-1##6 9.946
R1480 net@1360#15pin@499_polysilicon-1##6 net@1360#15pin@499_polysilicon-1##7 9.946
R1481 net@1360#15pin@499_polysilicon-1##7 net@1360#15pin@499_polysilicon-1##8 9.946
R1482 net@1360#15pin@499_polysilicon-1##8 net@1360#15pin@499_polysilicon-1##9 9.946
R1483 net@1360#15pin@499_polysilicon-1##9 net@1360#15pin@499_polysilicon-1##10 9.946
R1484 net@1360#15pin@499_polysilicon-1##10 net@1360#16pin@500_polysilicon-1 9.946
R1485 S0#66nmos@67_poly-left S0#66nmos@67_poly-left##0 9.688
R1486 S0#66nmos@67_poly-left##0 S0#66nmos@67_poly-left##1 9.688
R1487 S0#66nmos@67_poly-left##1 S0#66nmos@67_poly-left##2 9.688
R1488 S0#66nmos@67_poly-left##2 S0#67pin@501_polysilicon-1 9.688
R1489 S0 S0##0 9.429
R1490 S0##0 S0##1 9.429
R1491 S0##1 S0##2 9.429
R1492 S0##2 S0##3 9.429
R1493 S0##3 S0##4 9.429
R1494 S0##4 S0##5 9.429
R1495 S0##5 S0##6 9.429
R1496 S0##6 S0##7 9.429
R1497 S0##7 S0##8 9.429
R1498 S0##8 S0##9 9.429
R1499 S0##9 S0##10 9.429
R1500 S0##10 S0#66nmos@67_poly-left 9.429
R1501 net@1360#1pin@504_polysilicon-1 net@1360#1pin@504_polysilicon-1##0 5.425
R1502 net@1360#1pin@504_polysilicon-1##0 net@1360#16pin@500_polysilicon-1 5.425
R1503 net@1360#18nmos@66_poly-right net@1360#18nmos@66_poly-right##0 9.688
R1504 net@1360#18nmos@66_poly-right##0 net@1360#18nmos@66_poly-right##1 9.688
R1505 net@1360#18nmos@66_poly-right##1 net@1360#18nmos@66_poly-right##2 9.688
R1506 net@1360#18nmos@66_poly-right##2 net@1360#1pin@504_polysilicon-1 9.688
R1507 S0#53pin@507_polysilicon-1 S0#53pin@507_polysilicon-1##0 9.521
R1508 S0#53pin@507_polysilicon-1##0 S0#53pin@507_polysilicon-1##1 9.521
R1509 S0#53pin@507_polysilicon-1##1 S0#53pin@507_polysilicon-1##2 9.521
R1510 S0#53pin@507_polysilicon-1##2 S0#53pin@507_polysilicon-1##3 9.521
R1511 S0#53pin@507_polysilicon-1##3 S0#53pin@507_polysilicon-1##4 9.521
R1512 S0#53pin@507_polysilicon-1##4 S0#53pin@507_polysilicon-1##5 9.521
R1513 S0#53pin@507_polysilicon-1##5 S0#68pin@505_polysilicon-1 9.521
R1514 S0#68pin@505_polysilicon-1 S0#68pin@505_polysilicon-1##0 9.868
R1515 S0#68pin@505_polysilicon-1##0 S0#68pin@505_polysilicon-1##1 9.868
R1516 S0#68pin@505_polysilicon-1##1 S0#68pin@505_polysilicon-1##2 9.868
R1517 S0#68pin@505_polysilicon-1##2 S0#68pin@505_polysilicon-1##3 9.868
R1518 S0#68pin@505_polysilicon-1##3 S0#68pin@505_polysilicon-1##4 9.868
R1519 S0#68pin@505_polysilicon-1##4 S0#68pin@505_polysilicon-1##5 9.868
R1520 S0#68pin@505_polysilicon-1##5 S0#68pin@505_polysilicon-1##6 9.868
R1521 S0#68pin@505_polysilicon-1##6 S0#68pin@505_polysilicon-1##7 9.868
R1522 S0#68pin@505_polysilicon-1##7 S0#68pin@505_polysilicon-1##8 9.868
R1523 S0#68pin@505_polysilicon-1##8 S0#68pin@505_polysilicon-1##9 9.868
R1524 S0#68pin@505_polysilicon-1##9 S0#68pin@505_polysilicon-1##10 9.868
R1525 S0#68pin@505_polysilicon-1##10 S0#68pin@505_polysilicon-1##11 9.868
R1526 S0#68pin@505_polysilicon-1##11 S0#68pin@505_polysilicon-1##12 9.868
R1527 S0#68pin@505_polysilicon-1##12 S0#68pin@505_polysilicon-1##13 9.868
R1528 S0#68pin@505_polysilicon-1##13 S0#68pin@505_polysilicon-1##14 9.868
R1529 S0#68pin@505_polysilicon-1##14 S0#68pin@505_polysilicon-1##15 9.868
R1530 S0#68pin@505_polysilicon-1##15 S0#68pin@505_polysilicon-1##16 9.868
R1531 S0#68pin@505_polysilicon-1##16 S0#68pin@505_polysilicon-1##17 9.868
R1532 S0#68pin@505_polysilicon-1##17 S0#68pin@505_polysilicon-1##18 9.868
R1533 S0#68pin@505_polysilicon-1##18 S0#68pin@505_polysilicon-1##19 9.868
R1534 S0#68pin@505_polysilicon-1##19 S0#68pin@505_polysilicon-1##20 9.868
R1535 S0#68pin@505_polysilicon-1##20 S0#68pin@505_polysilicon-1##21 9.868
R1536 S0#68pin@505_polysilicon-1##21 S0#68pin@505_polysilicon-1##22 9.868
R1537 S0#68pin@505_polysilicon-1##22 S0#68pin@505_polysilicon-1##23 9.868
R1538 S0#68pin@505_polysilicon-1##23 S0#68pin@505_polysilicon-1##24 9.868
R1539 S0#68pin@505_polysilicon-1##24 S0#68pin@505_polysilicon-1##25 9.868
R1540 S0#68pin@505_polysilicon-1##25 S0#68pin@505_polysilicon-1##26 9.868
R1541 S0#68pin@505_polysilicon-1##26 S0#68pin@505_polysilicon-1##27 9.868
R1542 S0#68pin@505_polysilicon-1##27 S0#68pin@505_polysilicon-1##28 9.868
R1543 S0#68pin@505_polysilicon-1##28 S0#67pin@501_polysilicon-1 9.868
R1544 S0#69pmos@66_poly-left S0#69pmos@66_poly-left##0 9.688
R1545 S0#69pmos@66_poly-left##0 S0#69pmos@66_poly-left##1 9.688
R1546 S0#69pmos@66_poly-left##1 S0#69pmos@66_poly-left##2 9.688
R1547 S0#69pmos@66_poly-left##2 S0#68pin@505_polysilicon-1 9.688
R1548 net@1382 net@1382 0
R1549 S0#55pin@481_polysilicon-1 S0#55pin@481_polysilicon-1##0 9.972
R1550 S0#55pin@481_polysilicon-1##0 S0#55pin@481_polysilicon-1##1 9.972
R1551 S0#55pin@481_polysilicon-1##1 S0#55pin@481_polysilicon-1##2 9.972
R1552 S0#55pin@481_polysilicon-1##2 S0#55pin@481_polysilicon-1##3 9.972
R1553 S0#55pin@481_polysilicon-1##3 S0#55pin@481_polysilicon-1##4 9.972
R1554 S0#55pin@481_polysilicon-1##4 S0#55pin@481_polysilicon-1##5 9.972
R1555 S0#55pin@481_polysilicon-1##5 S0#55pin@481_polysilicon-1##6 9.972
R1556 S0#55pin@481_polysilicon-1##6 S0#55pin@481_polysilicon-1##7 9.972
R1557 S0#55pin@481_polysilicon-1##7 S0#55pin@481_polysilicon-1##8 9.972
R1558 S0#55pin@481_polysilicon-1##8 S0#55pin@481_polysilicon-1##9 9.972
R1559 S0#55pin@481_polysilicon-1##9 S0#55pin@481_polysilicon-1##10 9.972
R1560 S0#55pin@481_polysilicon-1##10 S0#55pin@481_polysilicon-1##11 9.972
R1561 S0#55pin@481_polysilicon-1##11 S0#55pin@481_polysilicon-1##12 9.972
R1562 S0#55pin@481_polysilicon-1##12 S0#55pin@481_polysilicon-1##13 9.972
R1563 S0#55pin@481_polysilicon-1##13 S0#55pin@481_polysilicon-1##14 9.972
R1564 S0#55pin@481_polysilicon-1##14 S0#55pin@481_polysilicon-1##15 9.972
R1565 S0#55pin@481_polysilicon-1##15 S0#55pin@481_polysilicon-1##16 9.972
R1566 S0#55pin@481_polysilicon-1##16 S0#55pin@481_polysilicon-1##17 9.972
R1567 S0#55pin@481_polysilicon-1##17 S0#55pin@481_polysilicon-1##18 9.972
R1568 S0#55pin@481_polysilicon-1##18 S0#55pin@481_polysilicon-1##19 9.972
R1569 S0#55pin@481_polysilicon-1##19 S0#55pin@481_polysilicon-1##20 9.972
R1570 S0#55pin@481_polysilicon-1##20 S0#55pin@481_polysilicon-1##21 9.972
R1571 S0#55pin@481_polysilicon-1##21 S0#55pin@481_polysilicon-1##22 9.972
R1572 S0#55pin@481_polysilicon-1##22 S0#55pin@481_polysilicon-1##23 9.972
R1573 S0#55pin@481_polysilicon-1##23 S0#55pin@481_polysilicon-1##24 9.972
R1574 S0#55pin@481_polysilicon-1##24 S0#55pin@481_polysilicon-1##25 9.972
R1575 S0#55pin@481_polysilicon-1##25 S0#55pin@481_polysilicon-1##26 9.972
R1576 S0#55pin@481_polysilicon-1##26 S0#55pin@481_polysilicon-1##27 9.972
R1577 S0#55pin@481_polysilicon-1##27 S0#55pin@481_polysilicon-1##28 9.972
R1578 S0#55pin@481_polysilicon-1##28 S0#53pin@507_polysilicon-1 9.972
R1579 S0#70nmos@57_poly-left S0#70nmos@57_poly-left##0 9.688
R1580 S0#70nmos@57_poly-left##0 S0#70nmos@57_poly-left##1 9.688
R1581 S0#70nmos@57_poly-left##1 S0#70nmos@57_poly-left##2 9.688
R1582 S0#70nmos@57_poly-left##2 S0#42pin@424_polysilicon-1 9.688
R1583 net@1276#13pin@450_polysilicon-1 net@1276#13pin@450_polysilicon-1##0 9.858
R1584 net@1276#13pin@450_polysilicon-1##0 net@1276#13pin@450_polysilicon-1##1 9.858
R1585 net@1276#13pin@450_polysilicon-1##1 net@1276#13pin@450_polysilicon-1##2 9.858
R1586 net@1276#13pin@450_polysilicon-1##2 net@1276#13pin@450_polysilicon-1##3 9.858
R1587 net@1276#13pin@450_polysilicon-1##3 net@1276#13pin@450_polysilicon-1##4 9.858
R1588 net@1276#13pin@450_polysilicon-1##4 net@1276#13pin@450_polysilicon-1##5 9.858
R1589 net@1276#13pin@450_polysilicon-1##5 net@1276#13pin@450_polysilicon-1##6 9.858
R1590 net@1276#13pin@450_polysilicon-1##6 net@1276#13pin@450_polysilicon-1##7 9.858
R1591 net@1276#13pin@450_polysilicon-1##7 net@1276#13pin@450_polysilicon-1##8 9.858
R1592 net@1276#13pin@450_polysilicon-1##8 net@1276#13pin@450_polysilicon-1##9 9.858
R1593 net@1276#13pin@450_polysilicon-1##9 net@1276#13pin@450_polysilicon-1##10 9.858
R1594 net@1276#13pin@450_polysilicon-1##10 net@1276#13pin@450_polysilicon-1##11 9.858
R1595 net@1276#13pin@450_polysilicon-1##11 net@1276#13pin@450_polysilicon-1##12 9.858
R1596 net@1276#13pin@450_polysilicon-1##12 net@1276#13pin@450_polysilicon-1##13 9.858
R1597 net@1276#13pin@450_polysilicon-1##13 net@1276#13pin@450_polysilicon-1##14 9.858
R1598 net@1276#13pin@450_polysilicon-1##14 net@1276#13pin@450_polysilicon-1##15 9.858
R1599 net@1276#13pin@450_polysilicon-1##15 net@1276#13pin@450_polysilicon-1##16 9.858
R1600 net@1276#13pin@450_polysilicon-1##16 net@1276#13pin@450_polysilicon-1##17 9.858
R1601 net@1276#13pin@450_polysilicon-1##17 net@1276#13pin@450_polysilicon-1##18 9.858
R1602 net@1276#13pin@450_polysilicon-1##18 net@1276#13pin@450_polysilicon-1##19 9.858
R1603 net@1276#13pin@450_polysilicon-1##19 net@1276#13pin@450_polysilicon-1##20 9.858
R1604 net@1276#13pin@450_polysilicon-1##20 net@1276#13pin@450_polysilicon-1##21 9.858
R1605 net@1276#13pin@450_polysilicon-1##21 net@1276#13pin@450_polysilicon-1##22 9.858
R1606 net@1276#13pin@450_polysilicon-1##22 net@1276#13pin@450_polysilicon-1##23 9.858
R1607 net@1276#13pin@450_polysilicon-1##23 net@1276#11pin@446_polysilicon-1 9.858
R1608 net@1276#14pmos@57_poly-left net@1276#14pmos@57_poly-left##0 9.688
R1609 net@1276#14pmos@57_poly-left##0 net@1276#14pmos@57_poly-left##1 9.688
R1610 net@1276#14pmos@57_poly-left##1 net@1276#14pmos@57_poly-left##2 9.688
R1611 net@1276#14pmos@57_poly-left##2 net@1276#13pin@450_polysilicon-1 9.688
R1612 net@1276#15nmos@56_poly-left net@1276#15nmos@56_poly-left##0 9.688
R1613 net@1276#15nmos@56_poly-left##0 net@1276#15nmos@56_poly-left##1 9.688
R1614 net@1276#15nmos@56_poly-left##1 net@1276#15nmos@56_poly-left##2 9.688
R1615 net@1276#15nmos@56_poly-left##2 net@1276#16pin@451_polysilicon-1 9.688
R1616 net@1276#13pin@450_polysilicon-1 net@1276#13pin@450_polysilicon-1##0 9.743
R1617 net@1276#13pin@450_polysilicon-1##0 net@1276#13pin@450_polysilicon-1##1 9.743
R1618 net@1276#13pin@450_polysilicon-1##1 net@1276#13pin@450_polysilicon-1##2 9.743
R1619 net@1276#13pin@450_polysilicon-1##2 net@1276#13pin@450_polysilicon-1##3 9.743
R1620 net@1276#13pin@450_polysilicon-1##3 net@1276#13pin@450_polysilicon-1##4 9.743
R1621 net@1276#13pin@450_polysilicon-1##4 net@1276#13pin@450_polysilicon-1##5 9.743
R1622 net@1276#13pin@450_polysilicon-1##5 net@1276#16pin@451_polysilicon-1 9.743
R1623 net@1276 net@1276##0 9.3
R1624 net@1276##0 net@1276##1 9.3
R1625 net@1276##1 net@1276##2 9.3
R1626 net@1276##2 net@1276##3 9.3
R1627 net@1276##3 net@1276##4 9.3
R1628 net@1276##4 net@1276##5 9.3
R1629 net@1276##5 net@1276##6 9.3
R1630 net@1276##6 net@1276#16pin@451_polysilicon-1 9.3
R1631 net@1271#6nmos@60_poly-left net@1271#6nmos@60_poly-left##0 9.688
R1632 net@1271#6nmos@60_poly-left##0 net@1271#6nmos@60_poly-left##1 9.688
R1633 net@1271#6nmos@60_poly-left##1 net@1271#6nmos@60_poly-left##2 9.688
R1634 net@1271#6nmos@60_poly-left##2 net@1271#7pin@455_polysilicon-1 9.688
R1635 net@1327 net@1327 0
R1636 net@1271#8pmos@61_poly-left net@1271#8pmos@61_poly-left##0 9.688
R1637 net@1271#8pmos@61_poly-left##0 net@1271#8pmos@61_poly-left##1 9.688
R1638 net@1271#8pmos@61_poly-left##1 net@1271#8pmos@61_poly-left##2 9.688
R1639 net@1271#8pmos@61_poly-left##2 net@1271#9pin@456_polysilicon-1 9.688
R1640 net@1271#9pin@456_polysilicon-1 net@1271#9pin@456_polysilicon-1##0 9.92
R1641 net@1271#9pin@456_polysilicon-1##0 net@1271#9pin@456_polysilicon-1##1 9.92
R1642 net@1271#9pin@456_polysilicon-1##1 net@1271#9pin@456_polysilicon-1##2 9.92
R1643 net@1271#9pin@456_polysilicon-1##2 net@1271#9pin@456_polysilicon-1##3 9.92
R1644 net@1271#9pin@456_polysilicon-1##3 net@1271#11pin@458_polysilicon-1 9.92
R1645 net@1271#11pin@458_polysilicon-1 net@1271#11pin@458_polysilicon-1##0 9.3
R1646 net@1271#11pin@458_polysilicon-1##0 net@1271#11pin@458_polysilicon-1##1 9.3
R1647 net@1271#11pin@458_polysilicon-1##1 net@1271#11pin@458_polysilicon-1##2 9.3
R1648 net@1271#11pin@458_polysilicon-1##2 net@1271#11pin@458_polysilicon-1##3 9.3
R1649 net@1271#11pin@458_polysilicon-1##3 net@1271#11pin@458_polysilicon-1##4 9.3
R1650 net@1271#11pin@458_polysilicon-1##4 net@1271#7pin@455_polysilicon-1 9.3
R1651 net@1271 net@1271##0 5.425
R1652 net@1271##0 net@1271#11pin@458_polysilicon-1 5.425
R1653 S1#47pin@422_polysilicon-1 S1#47pin@422_polysilicon-1##0 9.652
R1654 S1#47pin@422_polysilicon-1##0 S1#47pin@422_polysilicon-1##1 9.652
R1655 S1#47pin@422_polysilicon-1##1 S1#47pin@422_polysilicon-1##2 9.652
R1656 S1#47pin@422_polysilicon-1##2 S1#47pin@422_polysilicon-1##3 9.652
R1657 S1#47pin@422_polysilicon-1##3 S1#47pin@422_polysilicon-1##4 9.652
R1658 S1#47pin@422_polysilicon-1##4 S1#47pin@422_polysilicon-1##5 9.652
R1659 S1#47pin@422_polysilicon-1##5 S1#47pin@422_polysilicon-1##6 9.652
R1660 S1#47pin@422_polysilicon-1##6 S1#47pin@422_polysilicon-1##7 9.652
R1661 S1#47pin@422_polysilicon-1##7 S1#47pin@422_polysilicon-1##8 9.652
R1662 S1#47pin@422_polysilicon-1##8 S1#47pin@422_polysilicon-1##9 9.652
R1663 S1#47pin@422_polysilicon-1##9 S1#47pin@422_polysilicon-1##10 9.652
R1664 S1#47pin@422_polysilicon-1##10 S1#47pin@422_polysilicon-1##11 9.652
R1665 S1#47pin@422_polysilicon-1##11 S1#47pin@422_polysilicon-1##12 9.652
R1666 S1#47pin@422_polysilicon-1##12 S1#47pin@422_polysilicon-1##13 9.652
R1667 S1#47pin@422_polysilicon-1##13 S1#47pin@422_polysilicon-1##14 9.652
R1668 S1#47pin@422_polysilicon-1##14 S1#47pin@422_polysilicon-1##15 9.652
R1669 S1#47pin@422_polysilicon-1##15 S1#47pin@422_polysilicon-1##16 9.652
R1670 S1#47pin@422_polysilicon-1##16 S1#47pin@422_polysilicon-1##17 9.652
R1671 S1#47pin@422_polysilicon-1##17 S1#47pin@422_polysilicon-1##18 9.652
R1672 S1#47pin@422_polysilicon-1##18 S1#47pin@422_polysilicon-1##19 9.652
R1673 S1#47pin@422_polysilicon-1##19 S1#47pin@422_polysilicon-1##20 9.652
R1674 S1#47pin@422_polysilicon-1##20 S1#48pin@459_polysilicon-1 9.652
R1675 S1#28pin@431_polysilicon-1 S1#28pin@431_polysilicon-1##0 9.61
R1676 S1#28pin@431_polysilicon-1##0 S1#28pin@431_polysilicon-1##1 9.61
R1677 S1#28pin@431_polysilicon-1##1 S1#28pin@431_polysilicon-1##2 9.61
R1678 S1#28pin@431_polysilicon-1##2 S1#28pin@431_polysilicon-1##3 9.61
R1679 S1#28pin@431_polysilicon-1##3 S1#48pin@459_polysilicon-1 9.61
R1680 S1#49nmos@61_poly-left S1#49nmos@61_poly-left##0 9.688
R1681 S1#49nmos@61_poly-left##0 S1#49nmos@61_poly-left##1 9.688
R1682 S1#49nmos@61_poly-left##1 S1#49nmos@61_poly-left##2 9.688
R1683 S1#49nmos@61_poly-left##2 S1#47pin@422_polysilicon-1 9.688
R1684 net@1594 net@1594 0
R1685 net@1594 net@1594 0
R1686 S1#50pmos@60_poly-left S1#50pmos@60_poly-left##0 9.688
R1687 S1#50pmos@60_poly-left##0 S1#50pmos@60_poly-left##1 9.688
R1688 S1#50pmos@60_poly-left##1 S1#50pmos@60_poly-left##2 9.688
R1689 S1#50pmos@60_poly-left##2 S1#51pin@421_polysilicon-1 9.688
R1690 S1#51pin@421_polysilicon-1 S1#51pin@421_polysilicon-1##0 9.958
R1691 S1#51pin@421_polysilicon-1##0 S1#51pin@421_polysilicon-1##1 9.958
R1692 S1#51pin@421_polysilicon-1##1 S1#51pin@421_polysilicon-1##2 9.958
R1693 S1#51pin@421_polysilicon-1##2 S1#51pin@421_polysilicon-1##3 9.958
R1694 S1#51pin@421_polysilicon-1##3 S1#51pin@421_polysilicon-1##4 9.958
R1695 S1#51pin@421_polysilicon-1##4 S1#51pin@421_polysilicon-1##5 9.958
R1696 S1#51pin@421_polysilicon-1##5 S1#51pin@421_polysilicon-1##6 9.958
R1697 S1#51pin@421_polysilicon-1##6 S1#51pin@421_polysilicon-1##7 9.958
R1698 S1#51pin@421_polysilicon-1##7 S1#51pin@421_polysilicon-1##8 9.958
R1699 S1#51pin@421_polysilicon-1##8 S1#51pin@421_polysilicon-1##9 9.958
R1700 S1#51pin@421_polysilicon-1##9 S1#51pin@421_polysilicon-1##10 9.958
R1701 S1#51pin@421_polysilicon-1##10 S1#51pin@421_polysilicon-1##11 9.958
R1702 S1#51pin@421_polysilicon-1##11 S1#51pin@421_polysilicon-1##12 9.958
R1703 S1#51pin@421_polysilicon-1##12 S1#51pin@421_polysilicon-1##13 9.958
R1704 S1#51pin@421_polysilicon-1##13 S1#51pin@421_polysilicon-1##14 9.958
R1705 S1#51pin@421_polysilicon-1##14 S1#51pin@421_polysilicon-1##15 9.958
R1706 S1#51pin@421_polysilicon-1##15 S1#51pin@421_polysilicon-1##16 9.958
R1707 S1#51pin@421_polysilicon-1##16 S1#51pin@421_polysilicon-1##17 9.958
R1708 S1#51pin@421_polysilicon-1##17 S1#51pin@421_polysilicon-1##18 9.958
R1709 S1#51pin@421_polysilicon-1##18 S1#51pin@421_polysilicon-1##19 9.958
R1710 S1#51pin@421_polysilicon-1##19 S1#51pin@421_polysilicon-1##20 9.958
R1711 S1#51pin@421_polysilicon-1##20 S1#51pin@421_polysilicon-1##21 9.958
R1712 S1#51pin@421_polysilicon-1##21 S1#51pin@421_polysilicon-1##22 9.958
R1713 S1#51pin@421_polysilicon-1##22 S1#51pin@421_polysilicon-1##23 9.958
R1714 S1#51pin@421_polysilicon-1##23 S1#51pin@421_polysilicon-1##24 9.958
R1715 S1#51pin@421_polysilicon-1##24 S1#51pin@421_polysilicon-1##25 9.958
R1716 S1#51pin@421_polysilicon-1##25 S1#51pin@421_polysilicon-1##26 9.958
R1717 S1#51pin@421_polysilicon-1##26 S1#51pin@421_polysilicon-1##27 9.958
R1718 S1#51pin@421_polysilicon-1##27 S1#51pin@421_polysilicon-1##28 9.958
R1719 S1#51pin@421_polysilicon-1##28 S1#51pin@421_polysilicon-1##29 9.958
R1720 S1#51pin@421_polysilicon-1##29 S1#51pin@421_polysilicon-1##30 9.958
R1721 S1#51pin@421_polysilicon-1##30 S1#51pin@421_polysilicon-1##31 9.958
R1722 S1#51pin@421_polysilicon-1##31 S1#47pin@422_polysilicon-1 9.958
R1723 S0#71pmos@56_poly-left S0#71pmos@56_poly-left##0 9.688
R1724 S0#71pmos@56_poly-left##0 S0#71pmos@56_poly-left##1 9.688
R1725 S0#71pmos@56_poly-left##1 S0#71pmos@56_poly-left##2 9.688
R1726 S0#71pmos@56_poly-left##2 S0#50pin@423_polysilicon-1 9.688
R1727 net@1273 net@1273 0
R1728 net@1632 net@1632 0
R1729 net@1637 net@1637 0
R1730 net@1644#2contact@624_metal-1-n-act net@1644#2contact@624_metal-1-n-act 0
R1731 S2#2pmos@79_poly-right S2#2pmos@79_poly-right##0 9.937
R1732 S2#2pmos@79_poly-right##0 S2#2pmos@79_poly-right##1 9.937
R1733 S2#2pmos@79_poly-right##1 S2#2pmos@79_poly-right##2 9.937
R1734 S2#2pmos@79_poly-right##2 S2#2pmos@79_poly-right##3 9.937
R1735 S2#2pmos@79_poly-right##3 S2#2pmos@79_poly-right##4 9.937
R1736 S2#2pmos@79_poly-right##4 S2#2pmos@79_poly-right##5 9.937
R1737 S2#2pmos@79_poly-right##5 S2#2pmos@79_poly-right##6 9.937
R1738 S2#2pmos@79_poly-right##6 S2#2pmos@79_poly-right##7 9.937
R1739 S2#2pmos@79_poly-right##7 S2#2pmos@79_poly-right##8 9.937
R1740 S2#2pmos@79_poly-right##8 S2#2pmos@79_poly-right##9 9.937
R1741 S2#2pmos@79_poly-right##9 S2#2pmos@79_poly-right##10 9.937
R1742 S2#2pmos@79_poly-right##10 S2#2pmos@79_poly-right##11 9.937
R1743 S2#2pmos@79_poly-right##11 S2#2pmos@79_poly-right##12 9.937
R1744 S2#2pmos@79_poly-right##12 S2#2pmos@79_poly-right##13 9.937
R1745 S2#2pmos@79_poly-right##13 S2#2pmos@79_poly-right##14 9.937
R1746 S2#2pmos@79_poly-right##14 S2#2pmos@79_poly-right##15 9.937
R1747 S2#2pmos@79_poly-right##15 S2#2pmos@79_poly-right##16 9.937
R1748 S2#2pmos@79_poly-right##16 S2#2pmos@79_poly-right##17 9.937
R1749 S2#2pmos@79_poly-right##17 S2#2pmos@79_poly-right##18 9.937
R1750 S2#2pmos@79_poly-right##18 S2#2pmos@79_poly-right##19 9.937
R1751 S2#2pmos@79_poly-right##19 S2#2pmos@79_poly-right##20 9.937
R1752 S2#2pmos@79_poly-right##20 S2#2pmos@79_poly-right##21 9.937
R1753 S2#2pmos@79_poly-right##21 S2#2pmos@79_poly-right##22 9.937
R1754 S2#2pmos@79_poly-right##22 S2#2pmos@79_poly-right##23 9.937
R1755 S2#2pmos@79_poly-right##23 S2#2pmos@79_poly-right##24 9.937
R1756 S2#2pmos@79_poly-right##24 S2#2pmos@79_poly-right##25 9.937
R1757 S2#2pmos@79_poly-right##25 S2#2pmos@79_poly-right##26 9.937
R1758 S2#2pmos@79_poly-right##26 S2#2pmos@79_poly-right##27 9.937
R1759 S2#2pmos@79_poly-right##27 S2#2pmos@79_poly-right##28 9.937
R1760 S2#2pmos@79_poly-right##28 S2#2pmos@79_poly-right##29 9.937
R1761 S2#2pmos@79_poly-right##29 S2#2pmos@79_poly-right##30 9.937
R1762 S2#2pmos@79_poly-right##30 S2#2pmos@79_poly-right##31 9.937
R1763 S2#2pmos@79_poly-right##31 S2#2pmos@79_poly-right##32 9.937
R1764 S2#2pmos@79_poly-right##32 S2#2pmos@79_poly-right##33 9.937
R1765 S2#2pmos@79_poly-right##33 S2#2pmos@79_poly-right##34 9.937
R1766 S2#2pmos@79_poly-right##34 S2#2pmos@79_poly-right##35 9.937
R1767 S2#2pmos@79_poly-right##35 S2#2pmos@79_poly-right##36 9.937
R1768 S2#2pmos@79_poly-right##36 S2#2pmos@79_poly-right##37 9.937
R1769 S2#2pmos@79_poly-right##37 S2#2pmos@79_poly-right##38 9.937
R1770 S2#2pmos@79_poly-right##38 S2#2pmos@79_poly-right##39 9.937
R1771 S2#2pmos@79_poly-right##39 S2#2pmos@79_poly-right##40 9.937
R1772 S2#2pmos@79_poly-right##40 S2#2pmos@79_poly-right##41 9.937
R1773 S2#2pmos@79_poly-right##41 S2#2pmos@79_poly-right##42 9.937
R1774 S2#2pmos@79_poly-right##42 S2#2pmos@79_poly-right##43 9.937
R1775 S2#2pmos@79_poly-right##43 S2#2pmos@79_poly-right##44 9.937
R1776 S2#2pmos@79_poly-right##44 S2#2pmos@79_poly-right##45 9.937
R1777 S2#2pmos@79_poly-right##45 S2#2pmos@79_poly-right##46 9.937
R1778 S2#2pmos@79_poly-right##46 S2#2pmos@79_poly-right##47 9.937
R1779 S2#2pmos@79_poly-right##47 S2#2pmos@79_poly-right##48 9.937
R1780 S2#2pmos@79_poly-right##48 S2#2pmos@79_poly-right##49 9.937
R1781 S2#2pmos@79_poly-right##49 S2#2pmos@79_poly-right##50 9.937
R1782 S2#2pmos@79_poly-right##50 S2#2pmos@79_poly-right##51 9.937
R1783 S2#2pmos@79_poly-right##51 S2#2pmos@79_poly-right##52 9.937
R1784 S2#2pmos@79_poly-right##52 S2#2pmos@79_poly-right##53 9.937
R1785 S2#2pmos@79_poly-right##53 S2#2pmos@79_poly-right##54 9.937
R1786 S2#2pmos@79_poly-right##54 S2#3pin@544_polysilicon-1 9.937
R1787 S2#3pin@544_polysilicon-1 S2#3pin@544_polysilicon-1##0 9.688
R1788 S2#3pin@544_polysilicon-1##0 S2#3pin@544_polysilicon-1##1 9.688
R1789 S2#3pin@544_polysilicon-1##1 S2#3pin@544_polysilicon-1##2 9.688
R1790 S2#3pin@544_polysilicon-1##2 S2#3pin@544_polysilicon-1##3 9.688
R1791 S2#3pin@544_polysilicon-1##3 S2#3pin@544_polysilicon-1##4 9.688
R1792 S2#3pin@544_polysilicon-1##4 S2#3pin@544_polysilicon-1##5 9.688
R1793 S2#3pin@544_polysilicon-1##5 S2#3pin@544_polysilicon-1##6 9.688
R1794 S2#3pin@544_polysilicon-1##6 S2#4nmos@79_poly-right 9.688
R1795 net@1632 net@1632 0
R1796 S2#0contact@626_metal-1-metal-2 S2#0contact@626_metal-1-metal-2##0 9.92
R1797 S2#0contact@626_metal-1-metal-2##0 S2#0contact@626_metal-1-metal-2##1 9.92
R1798 S2#0contact@626_metal-1-metal-2##1 S2#0contact@626_metal-1-metal-2##2 9.92
R1799 S2#0contact@626_metal-1-metal-2##2 S2#0contact@626_metal-1-metal-2##3 9.92
R1800 S2#0contact@626_metal-1-metal-2##3 S2#0contact@626_metal-1-metal-2##4 9.92
R1801 S2#0contact@626_metal-1-metal-2##4 S2#0contact@626_metal-1-metal-2##5 9.92
R1802 S2#0contact@626_metal-1-metal-2##5 S2#0contact@626_metal-1-metal-2##6 9.92
R1803 S2#0contact@626_metal-1-metal-2##6 S2#0contact@626_metal-1-metal-2##7 9.92
R1804 S2#0contact@626_metal-1-metal-2##7 S2#0contact@626_metal-1-metal-2##8 9.92
R1805 S2#0contact@626_metal-1-metal-2##8 S2#3pin@544_polysilicon-1 9.92
R1806 net@1644 net@1644#2contact@624_metal-1-n-act 4.927
R1807 S3#2pin@547_polysilicon-1 S3#2pin@547_polysilicon-1##0 9.688
R1808 S3#2pin@547_polysilicon-1##0 S3#2pin@547_polysilicon-1##1 9.688
R1809 S3#2pin@547_polysilicon-1##1 S3#2pin@547_polysilicon-1##2 9.688
R1810 S3#2pin@547_polysilicon-1##2 S3#2pin@547_polysilicon-1##3 9.688
R1811 S3#2pin@547_polysilicon-1##3 S3#2pin@547_polysilicon-1##4 9.688
R1812 S3#2pin@547_polysilicon-1##4 S3#2pin@547_polysilicon-1##5 9.688
R1813 S3#2pin@547_polysilicon-1##5 S3#2pin@547_polysilicon-1##6 9.688
R1814 S3#2pin@547_polysilicon-1##6 S3#2pin@547_polysilicon-1##7 9.688
R1815 S3#2pin@547_polysilicon-1##7 S3#2pin@547_polysilicon-1##8 9.688
R1816 S3#2pin@547_polysilicon-1##8 S3#2pin@547_polysilicon-1##9 9.688
R1817 S3#2pin@547_polysilicon-1##9 S3#2pin@547_polysilicon-1##10 9.688
R1818 S3#2pin@547_polysilicon-1##10 S3#2pin@547_polysilicon-1##11 9.688
R1819 S3#2pin@547_polysilicon-1##11 S3#2pin@547_polysilicon-1##12 9.688
R1820 S3#2pin@547_polysilicon-1##12 S3#2pin@547_polysilicon-1##13 9.688
R1821 S3#2pin@547_polysilicon-1##13 S3#2pin@547_polysilicon-1##14 9.688
R1822 S3#2pin@547_polysilicon-1##14 S3#2pin@547_polysilicon-1##15 9.688
R1823 S3#2pin@547_polysilicon-1##15 S3#2pin@547_polysilicon-1##16 9.688
R1824 S3#2pin@547_polysilicon-1##16 S3#2pin@547_polysilicon-1##17 9.688
R1825 S3#2pin@547_polysilicon-1##17 S3#2pin@547_polysilicon-1##18 9.688
R1826 S3#2pin@547_polysilicon-1##18 S3#2pin@547_polysilicon-1##19 9.688
R1827 S3#2pin@547_polysilicon-1##19 S3#2pin@547_polysilicon-1##20 9.688
R1828 S3#2pin@547_polysilicon-1##20 S3#2pin@547_polysilicon-1##21 9.688
R1829 S3#2pin@547_polysilicon-1##21 S3#2pin@547_polysilicon-1##22 9.688
R1830 S3#2pin@547_polysilicon-1##22 S3#2pin@547_polysilicon-1##23 9.688
R1831 S3#2pin@547_polysilicon-1##23 S3#2pin@547_polysilicon-1##24 9.688
R1832 S3#2pin@547_polysilicon-1##24 S3#2pin@547_polysilicon-1##25 9.688
R1833 S3#2pin@547_polysilicon-1##25 S3#2pin@547_polysilicon-1##26 9.688
R1834 S3#2pin@547_polysilicon-1##26 S3#0pin@548_polysilicon-1 9.688
R1835 S3#5pmos@78_poly-right S3#5pmos@78_poly-right##0 9.89
R1836 S3#5pmos@78_poly-right##0 S3#5pmos@78_poly-right##1 9.89
R1837 S3#5pmos@78_poly-right##1 S3#5pmos@78_poly-right##2 9.89
R1838 S3#5pmos@78_poly-right##2 S3#5pmos@78_poly-right##3 9.89
R1839 S3#5pmos@78_poly-right##3 S3#5pmos@78_poly-right##4 9.89
R1840 S3#5pmos@78_poly-right##4 S3#5pmos@78_poly-right##5 9.89
R1841 S3#5pmos@78_poly-right##5 S3#5pmos@78_poly-right##6 9.89
R1842 S3#5pmos@78_poly-right##6 S3#5pmos@78_poly-right##7 9.89
R1843 S3#5pmos@78_poly-right##7 S3#5pmos@78_poly-right##8 9.89
R1844 S3#5pmos@78_poly-right##8 S3#5pmos@78_poly-right##9 9.89
R1845 S3#5pmos@78_poly-right##9 S3#5pmos@78_poly-right##10 9.89
R1846 S3#5pmos@78_poly-right##10 S3#5pmos@78_poly-right##11 9.89
R1847 S3#5pmos@78_poly-right##11 S3#5pmos@78_poly-right##12 9.89
R1848 S3#5pmos@78_poly-right##12 S3#5pmos@78_poly-right##13 9.89
R1849 S3#5pmos@78_poly-right##13 S3#5pmos@78_poly-right##14 9.89
R1850 S3#5pmos@78_poly-right##14 S3#5pmos@78_poly-right##15 9.89
R1851 S3#5pmos@78_poly-right##15 S3#5pmos@78_poly-right##16 9.89
R1852 S3#5pmos@78_poly-right##16 S3#5pmos@78_poly-right##17 9.89
R1853 S3#5pmos@78_poly-right##17 S3#5pmos@78_poly-right##18 9.89
R1854 S3#5pmos@78_poly-right##18 S3#5pmos@78_poly-right##19 9.89
R1855 S3#5pmos@78_poly-right##19 S3#5pmos@78_poly-right##20 9.89
R1856 S3#5pmos@78_poly-right##20 S3#5pmos@78_poly-right##21 9.89
R1857 S3#5pmos@78_poly-right##21 S3#5pmos@78_poly-right##22 9.89
R1858 S3#5pmos@78_poly-right##22 S3#5pmos@78_poly-right##23 9.89
R1859 S3#5pmos@78_poly-right##23 S3#5pmos@78_poly-right##24 9.89
R1860 S3#5pmos@78_poly-right##24 S3#5pmos@78_poly-right##25 9.89
R1861 S3#5pmos@78_poly-right##25 S3#5pmos@78_poly-right##26 9.89
R1862 S3#5pmos@78_poly-right##26 S3#5pmos@78_poly-right##27 9.89
R1863 S3#5pmos@78_poly-right##27 S3#5pmos@78_poly-right##28 9.89
R1864 S3#5pmos@78_poly-right##28 S3#5pmos@78_poly-right##29 9.89
R1865 S3#5pmos@78_poly-right##29 S3#5pmos@78_poly-right##30 9.89
R1866 S3#5pmos@78_poly-right##30 S3#5pmos@78_poly-right##31 9.89
R1867 S3#5pmos@78_poly-right##31 S3#5pmos@78_poly-right##32 9.89
R1868 S3#5pmos@78_poly-right##32 S3#5pmos@78_poly-right##33 9.89
R1869 S3#5pmos@78_poly-right##33 S3#5pmos@78_poly-right##34 9.89
R1870 S3#5pmos@78_poly-right##34 S3#5pmos@78_poly-right##35 9.89
R1871 S3#5pmos@78_poly-right##35 S3#5pmos@78_poly-right##36 9.89
R1872 S3#5pmos@78_poly-right##36 S3#5pmos@78_poly-right##37 9.89
R1873 S3#5pmos@78_poly-right##37 S3#5pmos@78_poly-right##38 9.89
R1874 S3#5pmos@78_poly-right##38 S3#5pmos@78_poly-right##39 9.89
R1875 S3#5pmos@78_poly-right##39 S3#5pmos@78_poly-right##40 9.89
R1876 S3#5pmos@78_poly-right##40 S3#5pmos@78_poly-right##41 9.89
R1877 S3#5pmos@78_poly-right##41 S3#5pmos@78_poly-right##42 9.89
R1878 S3#5pmos@78_poly-right##42 S3#5pmos@78_poly-right##43 9.89
R1879 S3#5pmos@78_poly-right##43 S3#5pmos@78_poly-right##44 9.89
R1880 S3#5pmos@78_poly-right##44 S3#5pmos@78_poly-right##45 9.89
R1881 S3#5pmos@78_poly-right##45 S3#5pmos@78_poly-right##46 9.89
R1882 S3#5pmos@78_poly-right##46 S3#5pmos@78_poly-right##47 9.89
R1883 S3#5pmos@78_poly-right##47 S3#5pmos@78_poly-right##48 9.89
R1884 S3#5pmos@78_poly-right##48 S3#5pmos@78_poly-right##49 9.89
R1885 S3#5pmos@78_poly-right##49 S3#5pmos@78_poly-right##50 9.89
R1886 S3#5pmos@78_poly-right##50 S3#5pmos@78_poly-right##51 9.89
R1887 S3#5pmos@78_poly-right##51 S3#5pmos@78_poly-right##52 9.89
R1888 S3#5pmos@78_poly-right##52 S3#5pmos@78_poly-right##53 9.89
R1889 S3#5pmos@78_poly-right##53 S3#5pmos@78_poly-right##54 9.89
R1890 S3#5pmos@78_poly-right##54 S3#5pmos@78_poly-right##55 9.89
R1891 S3#5pmos@78_poly-right##55 S3#5pmos@78_poly-right##56 9.89
R1892 S3#5pmos@78_poly-right##56 S3#5pmos@78_poly-right##57 9.89
R1893 S3#5pmos@78_poly-right##57 S3#5pmos@78_poly-right##58 9.89
R1894 S3#5pmos@78_poly-right##58 S3#5pmos@78_poly-right##59 9.89
R1895 S3#5pmos@78_poly-right##59 S3#5pmos@78_poly-right##60 9.89
R1896 S3#5pmos@78_poly-right##60 S3#5pmos@78_poly-right##61 9.89
R1897 S3#5pmos@78_poly-right##61 S3#6pin@550_polysilicon-1 9.89
R1898 S3#6pin@550_polysilicon-1 S3#0pin@548_polysilicon-1 7.75
R1899 S3#3contact@636_metal-1-metal-2 S3#3contact@636_metal-1-metal-2##0 5.425
R1900 S3#3contact@636_metal-1-metal-2##0 S3#6pin@550_polysilicon-1 5.425
R1901 net@1644#7pmos@75_poly-left net@1644#7pmos@75_poly-left##0 9.688
R1902 net@1644#7pmos@75_poly-left##0 net@1644#7pmos@75_poly-left##1 9.688
R1903 net@1644#7pmos@75_poly-left##1 net@1644#7pmos@75_poly-left##2 9.688
R1904 net@1644#7pmos@75_poly-left##2 net@1644#8pin@557_polysilicon-1 9.688
R1905 net@1644#8pin@557_polysilicon-1 net@1644#8pin@557_polysilicon-1##0 9.946
R1906 net@1644#8pin@557_polysilicon-1##0 net@1644#8pin@557_polysilicon-1##1 9.946
R1907 net@1644#8pin@557_polysilicon-1##1 net@1644#8pin@557_polysilicon-1##2 9.946
R1908 net@1644#8pin@557_polysilicon-1##2 net@1644#8pin@557_polysilicon-1##3 9.946
R1909 net@1644#8pin@557_polysilicon-1##3 net@1644#8pin@557_polysilicon-1##4 9.946
R1910 net@1644#8pin@557_polysilicon-1##4 net@1644#8pin@557_polysilicon-1##5 9.946
R1911 net@1644#8pin@557_polysilicon-1##5 net@1644#8pin@557_polysilicon-1##6 9.946
R1912 net@1644#8pin@557_polysilicon-1##6 net@1644#8pin@557_polysilicon-1##7 9.946
R1913 net@1644#8pin@557_polysilicon-1##7 net@1644#8pin@557_polysilicon-1##8 9.946
R1914 net@1644#8pin@557_polysilicon-1##8 net@1644#8pin@557_polysilicon-1##9 9.946
R1915 net@1644#8pin@557_polysilicon-1##9 net@1644#8pin@557_polysilicon-1##10 9.946
R1916 net@1644#8pin@557_polysilicon-1##10 net@1644#9pin@558_polysilicon-1 9.946
R1917 S2#10nmos@75_poly-left S2#10nmos@75_poly-left##0 9.688
R1918 S2#10nmos@75_poly-left##0 S2#10nmos@75_poly-left##1 9.688
R1919 S2#10nmos@75_poly-left##1 S2#10nmos@75_poly-left##2 9.688
R1920 S2#10nmos@75_poly-left##2 S2#11pin@559_polysilicon-1 9.688
R1921 S2#0contact@626_metal-1-metal-2 S2#0contact@626_metal-1-metal-2##0 9.429
R1922 S2#0contact@626_metal-1-metal-2##0 S2#0contact@626_metal-1-metal-2##1 9.429
R1923 S2#0contact@626_metal-1-metal-2##1 S2#0contact@626_metal-1-metal-2##2 9.429
R1924 S2#0contact@626_metal-1-metal-2##2 S2#0contact@626_metal-1-metal-2##3 9.429
R1925 S2#0contact@626_metal-1-metal-2##3 S2#0contact@626_metal-1-metal-2##4 9.429
R1926 S2#0contact@626_metal-1-metal-2##4 S2#0contact@626_metal-1-metal-2##5 9.429
R1927 S2#0contact@626_metal-1-metal-2##5 S2#0contact@626_metal-1-metal-2##6 9.429
R1928 S2#0contact@626_metal-1-metal-2##6 S2#0contact@626_metal-1-metal-2##7 9.429
R1929 S2#0contact@626_metal-1-metal-2##7 S2#0contact@626_metal-1-metal-2##8 9.429
R1930 S2#0contact@626_metal-1-metal-2##8 S2#0contact@626_metal-1-metal-2##9 9.429
R1931 S2#0contact@626_metal-1-metal-2##9 S2#0contact@626_metal-1-metal-2##10 9.429
R1932 S2#0contact@626_metal-1-metal-2##10 S2#10nmos@75_poly-left 9.429
R1933 net@1644#11pin@562_polysilicon-1 net@1644#11pin@562_polysilicon-1##0 5.425
R1934 net@1644#11pin@562_polysilicon-1##0 net@1644#9pin@558_polysilicon-1 5.425
R1935 net@1644#12nmos@74_poly-right net@1644#12nmos@74_poly-right##0 9.688
R1936 net@1644#12nmos@74_poly-right##0 net@1644#12nmos@74_poly-right##1 9.688
R1937 net@1644#12nmos@74_poly-right##1 net@1644#12nmos@74_poly-right##2 9.688
R1938 net@1644#12nmos@74_poly-right##2 net@1644#11pin@562_polysilicon-1 9.688
R1939 S2#6pin@540_polysilicon-1 S2#6pin@540_polysilicon-1##0 9.521
R1940 S2#6pin@540_polysilicon-1##0 S2#6pin@540_polysilicon-1##1 9.521
R1941 S2#6pin@540_polysilicon-1##1 S2#6pin@540_polysilicon-1##2 9.521
R1942 S2#6pin@540_polysilicon-1##2 S2#6pin@540_polysilicon-1##3 9.521
R1943 S2#6pin@540_polysilicon-1##3 S2#6pin@540_polysilicon-1##4 9.521
R1944 S2#6pin@540_polysilicon-1##4 S2#6pin@540_polysilicon-1##5 9.521
R1945 S2#6pin@540_polysilicon-1##5 S2#12pin@563_polysilicon-1 9.521
R1946 S2#12pin@563_polysilicon-1 S2#12pin@563_polysilicon-1##0 9.868
R1947 S2#12pin@563_polysilicon-1##0 S2#12pin@563_polysilicon-1##1 9.868
R1948 S2#12pin@563_polysilicon-1##1 S2#12pin@563_polysilicon-1##2 9.868
R1949 S2#12pin@563_polysilicon-1##2 S2#12pin@563_polysilicon-1##3 9.868
R1950 S2#12pin@563_polysilicon-1##3 S2#12pin@563_polysilicon-1##4 9.868
R1951 S2#12pin@563_polysilicon-1##4 S2#12pin@563_polysilicon-1##5 9.868
R1952 S2#12pin@563_polysilicon-1##5 S2#12pin@563_polysilicon-1##6 9.868
R1953 S2#12pin@563_polysilicon-1##6 S2#12pin@563_polysilicon-1##7 9.868
R1954 S2#12pin@563_polysilicon-1##7 S2#12pin@563_polysilicon-1##8 9.868
R1955 S2#12pin@563_polysilicon-1##8 S2#12pin@563_polysilicon-1##9 9.868
R1956 S2#12pin@563_polysilicon-1##9 S2#12pin@563_polysilicon-1##10 9.868
R1957 S2#12pin@563_polysilicon-1##10 S2#12pin@563_polysilicon-1##11 9.868
R1958 S2#12pin@563_polysilicon-1##11 S2#12pin@563_polysilicon-1##12 9.868
R1959 S2#12pin@563_polysilicon-1##12 S2#12pin@563_polysilicon-1##13 9.868
R1960 S2#12pin@563_polysilicon-1##13 S2#12pin@563_polysilicon-1##14 9.868
R1961 S2#12pin@563_polysilicon-1##14 S2#12pin@563_polysilicon-1##15 9.868
R1962 S2#12pin@563_polysilicon-1##15 S2#12pin@563_polysilicon-1##16 9.868
R1963 S2#12pin@563_polysilicon-1##16 S2#12pin@563_polysilicon-1##17 9.868
R1964 S2#12pin@563_polysilicon-1##17 S2#12pin@563_polysilicon-1##18 9.868
R1965 S2#12pin@563_polysilicon-1##18 S2#12pin@563_polysilicon-1##19 9.868
R1966 S2#12pin@563_polysilicon-1##19 S2#12pin@563_polysilicon-1##20 9.868
R1967 S2#12pin@563_polysilicon-1##20 S2#12pin@563_polysilicon-1##21 9.868
R1968 S2#12pin@563_polysilicon-1##21 S2#12pin@563_polysilicon-1##22 9.868
R1969 S2#12pin@563_polysilicon-1##22 S2#12pin@563_polysilicon-1##23 9.868
R1970 S2#12pin@563_polysilicon-1##23 S2#12pin@563_polysilicon-1##24 9.868
R1971 S2#12pin@563_polysilicon-1##24 S2#12pin@563_polysilicon-1##25 9.868
R1972 S2#12pin@563_polysilicon-1##25 S2#12pin@563_polysilicon-1##26 9.868
R1973 S2#12pin@563_polysilicon-1##26 S2#12pin@563_polysilicon-1##27 9.868
R1974 S2#12pin@563_polysilicon-1##27 S2#12pin@563_polysilicon-1##28 9.868
R1975 S2#12pin@563_polysilicon-1##28 S2#11pin@559_polysilicon-1 9.868
R1976 S2#13pmos@74_poly-left S2#13pmos@74_poly-left##0 9.688
R1977 S2#13pmos@74_poly-left##0 S2#13pmos@74_poly-left##1 9.688
R1978 S2#13pmos@74_poly-left##1 S2#13pmos@74_poly-left##2 9.688
R1979 S2#13pmos@74_poly-left##2 S2#12pin@563_polysilicon-1 9.688
R1980 net@1695 net@1695 0
R1981 S2#14pin@539_polysilicon-1 S2#14pin@539_polysilicon-1##0 9.972
R1982 S2#14pin@539_polysilicon-1##0 S2#14pin@539_polysilicon-1##1 9.972
R1983 S2#14pin@539_polysilicon-1##1 S2#14pin@539_polysilicon-1##2 9.972
R1984 S2#14pin@539_polysilicon-1##2 S2#14pin@539_polysilicon-1##3 9.972
R1985 S2#14pin@539_polysilicon-1##3 S2#14pin@539_polysilicon-1##4 9.972
R1986 S2#14pin@539_polysilicon-1##4 S2#14pin@539_polysilicon-1##5 9.972
R1987 S2#14pin@539_polysilicon-1##5 S2#14pin@539_polysilicon-1##6 9.972
R1988 S2#14pin@539_polysilicon-1##6 S2#14pin@539_polysilicon-1##7 9.972
R1989 S2#14pin@539_polysilicon-1##7 S2#14pin@539_polysilicon-1##8 9.972
R1990 S2#14pin@539_polysilicon-1##8 S2#14pin@539_polysilicon-1##9 9.972
R1991 S2#14pin@539_polysilicon-1##9 S2#14pin@539_polysilicon-1##10 9.972
R1992 S2#14pin@539_polysilicon-1##10 S2#14pin@539_polysilicon-1##11 9.972
R1993 S2#14pin@539_polysilicon-1##11 S2#14pin@539_polysilicon-1##12 9.972
R1994 S2#14pin@539_polysilicon-1##12 S2#14pin@539_polysilicon-1##13 9.972
R1995 S2#14pin@539_polysilicon-1##13 S2#14pin@539_polysilicon-1##14 9.972
R1996 S2#14pin@539_polysilicon-1##14 S2#14pin@539_polysilicon-1##15 9.972
R1997 S2#14pin@539_polysilicon-1##15 S2#14pin@539_polysilicon-1##16 9.972
R1998 S2#14pin@539_polysilicon-1##16 S2#14pin@539_polysilicon-1##17 9.972
R1999 S2#14pin@539_polysilicon-1##17 S2#14pin@539_polysilicon-1##18 9.972
R2000 S2#14pin@539_polysilicon-1##18 S2#14pin@539_polysilicon-1##19 9.972
R2001 S2#14pin@539_polysilicon-1##19 S2#14pin@539_polysilicon-1##20 9.972
R2002 S2#14pin@539_polysilicon-1##20 S2#14pin@539_polysilicon-1##21 9.972
R2003 S2#14pin@539_polysilicon-1##21 S2#14pin@539_polysilicon-1##22 9.972
R2004 S2#14pin@539_polysilicon-1##22 S2#14pin@539_polysilicon-1##23 9.972
R2005 S2#14pin@539_polysilicon-1##23 S2#14pin@539_polysilicon-1##24 9.972
R2006 S2#14pin@539_polysilicon-1##24 S2#14pin@539_polysilicon-1##25 9.972
R2007 S2#14pin@539_polysilicon-1##25 S2#14pin@539_polysilicon-1##26 9.972
R2008 S2#14pin@539_polysilicon-1##26 S2#14pin@539_polysilicon-1##27 9.972
R2009 S2#14pin@539_polysilicon-1##27 S2#14pin@539_polysilicon-1##28 9.972
R2010 S2#14pin@539_polysilicon-1##28 S2#6pin@540_polysilicon-1 9.972
R2011 S2#16nmos@73_poly-left S2#16nmos@73_poly-left##0 9.688
R2012 S2#16nmos@73_poly-left##0 S2#16nmos@73_poly-left##1 9.688
R2013 S2#16nmos@73_poly-left##1 S2#16nmos@73_poly-left##2 9.688
R2014 S2#16nmos@73_poly-left##2 S2#6pin@540_polysilicon-1 9.688
R2015 net@1644#13pin@566_polysilicon-1 net@1644#13pin@566_polysilicon-1##0 9.858
R2016 net@1644#13pin@566_polysilicon-1##0 net@1644#13pin@566_polysilicon-1##1 9.858
R2017 net@1644#13pin@566_polysilicon-1##1 net@1644#13pin@566_polysilicon-1##2 9.858
R2018 net@1644#13pin@566_polysilicon-1##2 net@1644#13pin@566_polysilicon-1##3 9.858
R2019 net@1644#13pin@566_polysilicon-1##3 net@1644#13pin@566_polysilicon-1##4 9.858
R2020 net@1644#13pin@566_polysilicon-1##4 net@1644#13pin@566_polysilicon-1##5 9.858
R2021 net@1644#13pin@566_polysilicon-1##5 net@1644#13pin@566_polysilicon-1##6 9.858
R2022 net@1644#13pin@566_polysilicon-1##6 net@1644#13pin@566_polysilicon-1##7 9.858
R2023 net@1644#13pin@566_polysilicon-1##7 net@1644#13pin@566_polysilicon-1##8 9.858
R2024 net@1644#13pin@566_polysilicon-1##8 net@1644#13pin@566_polysilicon-1##9 9.858
R2025 net@1644#13pin@566_polysilicon-1##9 net@1644#13pin@566_polysilicon-1##10 9.858
R2026 net@1644#13pin@566_polysilicon-1##10 net@1644#13pin@566_polysilicon-1##11 9.858
R2027 net@1644#13pin@566_polysilicon-1##11 net@1644#13pin@566_polysilicon-1##12 9.858
R2028 net@1644#13pin@566_polysilicon-1##12 net@1644#13pin@566_polysilicon-1##13 9.858
R2029 net@1644#13pin@566_polysilicon-1##13 net@1644#13pin@566_polysilicon-1##14 9.858
R2030 net@1644#13pin@566_polysilicon-1##14 net@1644#13pin@566_polysilicon-1##15 9.858
R2031 net@1644#13pin@566_polysilicon-1##15 net@1644#13pin@566_polysilicon-1##16 9.858
R2032 net@1644#13pin@566_polysilicon-1##16 net@1644#13pin@566_polysilicon-1##17 9.858
R2033 net@1644#13pin@566_polysilicon-1##17 net@1644#13pin@566_polysilicon-1##18 9.858
R2034 net@1644#13pin@566_polysilicon-1##18 net@1644#13pin@566_polysilicon-1##19 9.858
R2035 net@1644#13pin@566_polysilicon-1##19 net@1644#13pin@566_polysilicon-1##20 9.858
R2036 net@1644#13pin@566_polysilicon-1##20 net@1644#13pin@566_polysilicon-1##21 9.858
R2037 net@1644#13pin@566_polysilicon-1##21 net@1644#13pin@566_polysilicon-1##22 9.858
R2038 net@1644#13pin@566_polysilicon-1##22 net@1644#13pin@566_polysilicon-1##23 9.858
R2039 net@1644#13pin@566_polysilicon-1##23 net@1644#11pin@562_polysilicon-1 9.858
R2040 net@1644#14pmos@73_poly-left net@1644#14pmos@73_poly-left##0 9.688
R2041 net@1644#14pmos@73_poly-left##0 net@1644#14pmos@73_poly-left##1 9.688
R2042 net@1644#14pmos@73_poly-left##1 net@1644#14pmos@73_poly-left##2 9.688
R2043 net@1644#14pmos@73_poly-left##2 net@1644#13pin@566_polysilicon-1 9.688
R2044 net@1644#15nmos@72_poly-left net@1644#15nmos@72_poly-left##0 9.688
R2045 net@1644#15nmos@72_poly-left##0 net@1644#15nmos@72_poly-left##1 9.688
R2046 net@1644#15nmos@72_poly-left##1 net@1644#15nmos@72_poly-left##2 9.688
R2047 net@1644#15nmos@72_poly-left##2 net@1644#16pin@567_polysilicon-1 9.688
R2048 net@1644#13pin@566_polysilicon-1 net@1644#13pin@566_polysilicon-1##0 9.743
R2049 net@1644#13pin@566_polysilicon-1##0 net@1644#13pin@566_polysilicon-1##1 9.743
R2050 net@1644#13pin@566_polysilicon-1##1 net@1644#13pin@566_polysilicon-1##2 9.743
R2051 net@1644#13pin@566_polysilicon-1##2 net@1644#13pin@566_polysilicon-1##3 9.743
R2052 net@1644#13pin@566_polysilicon-1##3 net@1644#13pin@566_polysilicon-1##4 9.743
R2053 net@1644#13pin@566_polysilicon-1##4 net@1644#13pin@566_polysilicon-1##5 9.743
R2054 net@1644#13pin@566_polysilicon-1##5 net@1644#16pin@567_polysilicon-1 9.743
R2055 net@1644 net@1644##0 9.3
R2056 net@1644##0 net@1644##1 9.3
R2057 net@1644##1 net@1644##2 9.3
R2058 net@1644##2 net@1644##3 9.3
R2059 net@1644##3 net@1644##4 9.3
R2060 net@1644##4 net@1644##5 9.3
R2061 net@1644##5 net@1644##6 9.3
R2062 net@1644##6 net@1644#16pin@567_polysilicon-1 9.3
R2063 net@1637#7nmos@76_poly-left net@1637#7nmos@76_poly-left##0 9.688
R2064 net@1637#7nmos@76_poly-left##0 net@1637#7nmos@76_poly-left##1 9.688
R2065 net@1637#7nmos@76_poly-left##1 net@1637#7nmos@76_poly-left##2 9.688
R2066 net@1637#7nmos@76_poly-left##2 net@1637#8pin@571_polysilicon-1 9.688
R2067 net@1695 net@1695 0
R2068 net@1637#9pmos@77_poly-left net@1637#9pmos@77_poly-left##0 9.688
R2069 net@1637#9pmos@77_poly-left##0 net@1637#9pmos@77_poly-left##1 9.688
R2070 net@1637#9pmos@77_poly-left##1 net@1637#9pmos@77_poly-left##2 9.688
R2071 net@1637#9pmos@77_poly-left##2 net@1637#10pin@572_polysilicon-1 9.688
R2072 net@1637#10pin@572_polysilicon-1 net@1637#10pin@572_polysilicon-1##0 9.92
R2073 net@1637#10pin@572_polysilicon-1##0 net@1637#10pin@572_polysilicon-1##1 9.92
R2074 net@1637#10pin@572_polysilicon-1##1 net@1637#10pin@572_polysilicon-1##2 9.92
R2075 net@1637#10pin@572_polysilicon-1##2 net@1637#10pin@572_polysilicon-1##3 9.92
R2076 net@1637#10pin@572_polysilicon-1##3 net@1637#12pin@574_polysilicon-1 9.92
R2077 net@1637#12pin@574_polysilicon-1 net@1637#12pin@574_polysilicon-1##0 9.3
R2078 net@1637#12pin@574_polysilicon-1##0 net@1637#12pin@574_polysilicon-1##1 9.3
R2079 net@1637#12pin@574_polysilicon-1##1 net@1637#12pin@574_polysilicon-1##2 9.3
R2080 net@1637#12pin@574_polysilicon-1##2 net@1637#12pin@574_polysilicon-1##3 9.3
R2081 net@1637#12pin@574_polysilicon-1##3 net@1637#12pin@574_polysilicon-1##4 9.3
R2082 net@1637#12pin@574_polysilicon-1##4 net@1637#8pin@571_polysilicon-1 9.3
R2083 net@1637 net@1637##0 5.425
R2084 net@1637##0 net@1637#12pin@574_polysilicon-1 5.425
R2085 S3#8pin@538_polysilicon-1 S3#8pin@538_polysilicon-1##0 9.652
R2086 S3#8pin@538_polysilicon-1##0 S3#8pin@538_polysilicon-1##1 9.652
R2087 S3#8pin@538_polysilicon-1##1 S3#8pin@538_polysilicon-1##2 9.652
R2088 S3#8pin@538_polysilicon-1##2 S3#8pin@538_polysilicon-1##3 9.652
R2089 S3#8pin@538_polysilicon-1##3 S3#8pin@538_polysilicon-1##4 9.652
R2090 S3#8pin@538_polysilicon-1##4 S3#8pin@538_polysilicon-1##5 9.652
R2091 S3#8pin@538_polysilicon-1##5 S3#8pin@538_polysilicon-1##6 9.652
R2092 S3#8pin@538_polysilicon-1##6 S3#8pin@538_polysilicon-1##7 9.652
R2093 S3#8pin@538_polysilicon-1##7 S3#8pin@538_polysilicon-1##8 9.652
R2094 S3#8pin@538_polysilicon-1##8 S3#8pin@538_polysilicon-1##9 9.652
R2095 S3#8pin@538_polysilicon-1##9 S3#8pin@538_polysilicon-1##10 9.652
R2096 S3#8pin@538_polysilicon-1##10 S3#8pin@538_polysilicon-1##11 9.652
R2097 S3#8pin@538_polysilicon-1##11 S3#8pin@538_polysilicon-1##12 9.652
R2098 S3#8pin@538_polysilicon-1##12 S3#8pin@538_polysilicon-1##13 9.652
R2099 S3#8pin@538_polysilicon-1##13 S3#8pin@538_polysilicon-1##14 9.652
R2100 S3#8pin@538_polysilicon-1##14 S3#8pin@538_polysilicon-1##15 9.652
R2101 S3#8pin@538_polysilicon-1##15 S3#8pin@538_polysilicon-1##16 9.652
R2102 S3#8pin@538_polysilicon-1##16 S3#8pin@538_polysilicon-1##17 9.652
R2103 S3#8pin@538_polysilicon-1##17 S3#8pin@538_polysilicon-1##18 9.652
R2104 S3#8pin@538_polysilicon-1##18 S3#8pin@538_polysilicon-1##19 9.652
R2105 S3#8pin@538_polysilicon-1##19 S3#8pin@538_polysilicon-1##20 9.652
R2106 S3#8pin@538_polysilicon-1##20 S3#9pin@575_polysilicon-1 9.652
R2107 S3#2pin@547_polysilicon-1 S3#2pin@547_polysilicon-1##0 9.61
R2108 S3#2pin@547_polysilicon-1##0 S3#2pin@547_polysilicon-1##1 9.61
R2109 S3#2pin@547_polysilicon-1##1 S3#2pin@547_polysilicon-1##2 9.61
R2110 S3#2pin@547_polysilicon-1##2 S3#2pin@547_polysilicon-1##3 9.61
R2111 S3#2pin@547_polysilicon-1##3 S3#9pin@575_polysilicon-1 9.61
R2112 S3#10nmos@77_poly-left S3#10nmos@77_poly-left##0 9.688
R2113 S3#10nmos@77_poly-left##0 S3#10nmos@77_poly-left##1 9.688
R2114 S3#10nmos@77_poly-left##1 S3#10nmos@77_poly-left##2 9.688
R2115 S3#10nmos@77_poly-left##2 S3#8pin@538_polysilicon-1 9.688
R2116 Vout Vout 0
R2117 Vout Vout 0
R2118 S3#11pmos@76_poly-left S3#11pmos@76_poly-left##0 9.688
R2119 S3#11pmos@76_poly-left##0 S3#11pmos@76_poly-left##1 9.688
R2120 S3#11pmos@76_poly-left##1 S3#11pmos@76_poly-left##2 9.688
R2121 S3#11pmos@76_poly-left##2 S3#12pin@537_polysilicon-1 9.688
R2122 S3#12pin@537_polysilicon-1 S3#12pin@537_polysilicon-1##0 9.958
R2123 S3#12pin@537_polysilicon-1##0 S3#12pin@537_polysilicon-1##1 9.958
R2124 S3#12pin@537_polysilicon-1##1 S3#12pin@537_polysilicon-1##2 9.958
R2125 S3#12pin@537_polysilicon-1##2 S3#12pin@537_polysilicon-1##3 9.958
R2126 S3#12pin@537_polysilicon-1##3 S3#12pin@537_polysilicon-1##4 9.958
R2127 S3#12pin@537_polysilicon-1##4 S3#12pin@537_polysilicon-1##5 9.958
R2128 S3#12pin@537_polysilicon-1##5 S3#12pin@537_polysilicon-1##6 9.958
R2129 S3#12pin@537_polysilicon-1##6 S3#12pin@537_polysilicon-1##7 9.958
R2130 S3#12pin@537_polysilicon-1##7 S3#12pin@537_polysilicon-1##8 9.958
R2131 S3#12pin@537_polysilicon-1##8 S3#12pin@537_polysilicon-1##9 9.958
R2132 S3#12pin@537_polysilicon-1##9 S3#12pin@537_polysilicon-1##10 9.958
R2133 S3#12pin@537_polysilicon-1##10 S3#12pin@537_polysilicon-1##11 9.958
R2134 S3#12pin@537_polysilicon-1##11 S3#12pin@537_polysilicon-1##12 9.958
R2135 S3#12pin@537_polysilicon-1##12 S3#12pin@537_polysilicon-1##13 9.958
R2136 S3#12pin@537_polysilicon-1##13 S3#12pin@537_polysilicon-1##14 9.958
R2137 S3#12pin@537_polysilicon-1##14 S3#12pin@537_polysilicon-1##15 9.958
R2138 S3#12pin@537_polysilicon-1##15 S3#12pin@537_polysilicon-1##16 9.958
R2139 S3#12pin@537_polysilicon-1##16 S3#12pin@537_polysilicon-1##17 9.958
R2140 S3#12pin@537_polysilicon-1##17 S3#12pin@537_polysilicon-1##18 9.958
R2141 S3#12pin@537_polysilicon-1##18 S3#12pin@537_polysilicon-1##19 9.958
R2142 S3#12pin@537_polysilicon-1##19 S3#12pin@537_polysilicon-1##20 9.958
R2143 S3#12pin@537_polysilicon-1##20 S3#12pin@537_polysilicon-1##21 9.958
R2144 S3#12pin@537_polysilicon-1##21 S3#12pin@537_polysilicon-1##22 9.958
R2145 S3#12pin@537_polysilicon-1##22 S3#12pin@537_polysilicon-1##23 9.958
R2146 S3#12pin@537_polysilicon-1##23 S3#12pin@537_polysilicon-1##24 9.958
R2147 S3#12pin@537_polysilicon-1##24 S3#12pin@537_polysilicon-1##25 9.958
R2148 S3#12pin@537_polysilicon-1##25 S3#12pin@537_polysilicon-1##26 9.958
R2149 S3#12pin@537_polysilicon-1##26 S3#12pin@537_polysilicon-1##27 9.958
R2150 S3#12pin@537_polysilicon-1##27 S3#12pin@537_polysilicon-1##28 9.958
R2151 S3#12pin@537_polysilicon-1##28 S3#12pin@537_polysilicon-1##29 9.958
R2152 S3#12pin@537_polysilicon-1##29 S3#12pin@537_polysilicon-1##30 9.958
R2153 S3#12pin@537_polysilicon-1##30 S3#12pin@537_polysilicon-1##31 9.958
R2154 S3#12pin@537_polysilicon-1##31 S3#8pin@538_polysilicon-1 9.958
R2155 S2#17pmos@72_poly-left S2#17pmos@72_poly-left##0 9.688
R2156 S2#17pmos@72_poly-left##0 S2#17pmos@72_poly-left##1 9.688
R2157 S2#17pmos@72_poly-left##1 S2#17pmos@72_poly-left##2 9.688
R2158 S2#17pmos@72_poly-left##2 S2#14pin@539_polysilicon-1 9.688
R2159 net@962 net@962#12contact@597_metal-1-n-act 4.628
R2160 net@1413 net@1413#12contact@609_metal-1-n-act 4.628
R2161 S2#0contact@626_metal-1-metal-2 S2#0contact@626_metal-1-metal-2##0 5.538
C162 S2#0contact@626_metal-1-metal-2##0 0 7.064fF
R2162 S2#0contact@626_metal-1-metal-2##0 S2#18pin@592_metal-1 5.538
R2163 S2#18pin@592_metal-1 S2 4.524
R2164 S3#13pin@594_metal-1 S3 4.888
R2165 S3#3contact@636_metal-1-metal-2 S3#3contact@636_metal-1-metal-2##0 5.46
C163 S3#3contact@636_metal-1-metal-2##0 0 6.965fF
R2166 S3#3contact@636_metal-1-metal-2##0 S3#13pin@594_metal-1 5.46
R2167 S1#8contact@372_metal-1-metal-2 S1#21contact@438_metal-1-metal-2 6.604
R2168 S1#29contact@504_metal-1-metal-2 S1#21contact@438_metal-1-metal-2 6.604
R2169 S1 S1#29contact@504_metal-1-metal-2 6.604
R2170 S0#4contact@362_metal-1-metal-2 S0#22contact@428_metal-1-metal-2 6.058
R2171 S0#22contact@428_metal-1-metal-2 S0#36contact@494_metal-1-metal-2 6.084
R2172 S0#36contact@494_metal-1-metal-2 S0 6.097

* Spice Code nodes in cell cell '16-to-1-Mux-TG{lay}'
VDD VDD 0 DC 3.3
VGND GND 0 DC 0
Vin2 D0 0 PULSE (0 3.3 0n 5n 5n 50n 1600n)
Vin3 D1 0 PULSE (0 3.3 100n 5n 5n 50n 1600n)
Vin4 D2 0 PULSE (0 3.3 200n 5n 5n 50n 1600n)
Vin5 D3 0 PULSE (0 3.3 300n 5n 5n 50n 1600n)
Vin6 D4 0 PULSE (0 3.3 400n 5n 5n 50n 1600n)
Vin7 D5 0 PULSE (0 3.3 500n 5n 5n 50n 1600n)
Vin8 D6 0 PULSE (0 3.3 600n 5n 5n 50n 1600n)
Vin9 D7 0 PULSE (0 3.3 700n 5n 5n 50n 1600n)
Vin10 D8 0 PULSE (0 3.3 800n 5n 5n 50n 1600n)
Vin11 D9 0 PULSE (0 3.3 900n 5n 5n 50n 1600n)
Vin12 D10 0 PULSE (0 3.3 1000n 5n 5n 50n 1600n)
Vin13 D11 0 PULSE (0 3.3 1100n 5n 5n 50n 1600n)
Vin14 D12 0 PULSE (0 3.3 1200n 5n 5n 50n 1600n)
Vin15 D13 0 PULSE (0 3.3 1300n 5n 5n 50n 1600n)
Vin16 D14 0 PULSE (0 3.3 1400n 5n 5n 50n 1600n)
Vin17 D15 0 PULSE (0 3.3 1500n 5n 5n 50n 1600n)
Vin18 S0 0 PULSE (0 3.3 100n 5n 5n 100n 200n)
Vin19 S1 0 PULSE (0 3.3 200n 5n 5n 200n 400n)
Vin20 S2 0 PULSE (0 3.3 400n 5n 5n 400n 800n)
Vin21 S3 0 PULSE (0 3.3 800n 5n 5n 800n 1600n)
.TRAN 0 1600n
.include C:\Users\kille\Desktop\Electric\C5_models.txt
.END
