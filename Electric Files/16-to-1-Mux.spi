*** SPICE deck for cell 16-to-1-Mux{lay} from library 16-to-1-Mux
*** Created on Thu Nov 07, 2019 12:22:18
*** Last revised on Mon Nov 11, 2019 20:03:29
*** Written on Mon Nov 11, 2019 20:46:12 by Electric VLSI Design System, version 9.07
*** Layout tech: mocmos, foundry MOSIS
*** UC SPICE *** , MIN_RESIST 4.0, MIN_CAPAC 0.1FF
***    P-Active:	areacap=0.9FF/um^2,	edgecap=0.0FF/um,	res=2.5ohms/sq
***    N-Active:	areacap=0.9FF/um^2,	edgecap=0.0FF/um,	res=3.0ohms/sq
***    Polysilicon-1:	areacap=0.1467FF/um^2,	edgecap=0.0608FF/um,	res=6.2ohms/sq
***    Polysilicon-2:	areacap=1.0FF/um^2,	edgecap=0.0FF/um,	res=50.0ohms/sq
***    Transistor-Poly:	areacap=0.09FF/um^2,	edgecap=0.0FF/um,	res=2.5ohms/sq
***    Poly-Cut:	areacap=0.0FF/um^2,	edgecap=0.0FF/um,	res=2.2ohms/sq
***    Active-Cut:	areacap=0.0FF/um^2,	edgecap=0.0FF/um,	res=2.5ohms/sq
***    Metal-1:	areacap=0.1209FF/um^2,	edgecap=0.1104FF/um,	res=0.078ohms/sq
***    Via1:	areacap=0.0FF/um^2,	edgecap=0.0FF/um,	res=1.0ohms/sq
***    Metal-2:	areacap=0.0843FF/um^2,	edgecap=0.0974FF/um,	res=0.078ohms/sq
***    Via2:	areacap=0.0FF/um^2,	edgecap=0.0FF/um,	res=0.9ohms/sq
***    Metal-3:	areacap=0.0843FF/um^2,	edgecap=0.0974FF/um,	res=0.078ohms/sq
***    Via3:	areacap=0.0FF/um^2,	edgecap=0.0FF/um,	res=0.8ohms/sq
***    Metal-4:	areacap=0.0843FF/um^2,	edgecap=0.0974FF/um,	res=0.078ohms/sq
***    Via4:	areacap=0.0FF/um^2,	edgecap=0.0FF/um,	res=0.8ohms/sq
***    Metal-5:	areacap=0.0843FF/um^2,	edgecap=0.0974FF/um,	res=0.078ohms/sq
***    Via5:	areacap=0.0FF/um^2,	edgecap=0.0FF/um,	res=0.8ohms/sq
***    Metal-6:	areacap=0.0423FF/um^2,	edgecap=0.1273FF/um,	res=0.036ohms/sq
***    Hi-Res:	areacap=0.0FF/um^2,	edgecap=0.0FF/um,	res=1.0ohms/sq

*** TOP LEVEL CELL: 16-to-1-Mux{lay}
Mnmos@460 gnd net@6395 net@6310 gnd NMOS L=0.35U W=1.75U AS=1.378P AD=6.931P PS=3.675U PD=17.068U
Mnmos@461 net@6310 net@6297#6nmos@461_poly-left gnd gnd NMOS L=0.35U W=1.75U AS=6.931P AD=1.378P PS=17.068U PD=3.675U
Mnmos@462 net@6369 net@6310#13nmos@462_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=6.931P AD=1.991P PS=17.068U PD=5.775U
Mnmos@463 gnd net@6333#4nmos@463_poly-left net@6310 gnd NMOS L=0.35U W=1.75U AS=1.378P AD=6.931P PS=3.675U PD=17.068U
Mnmos@464 net@6310 net@6404#2nmos@464_poly-left gnd gnd NMOS L=0.35U W=1.75U AS=6.931P AD=1.378P PS=17.068U PD=3.675U
Mnmos@465 gnd D0#3nmos@465_poly-left net@6566 gnd NMOS L=0.35U W=1.75U AS=1.914P AD=6.931P PS=3.937U PD=17.068U
Mnmos@466 net@6566 net@6360#18nmos@466_poly-left net@6576 gnd NMOS L=0.35U W=1.75U AS=1.914P AD=1.914P PS=3.937U PD=3.937U
Mnmos@467 net@6395#3contact@2359_metal-1-polysilicon-1 net@6293#2nmos@467_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=6.931P AD=1.991P PS=17.068U PD=5.775U
Mnmos@468 net@6576 net@6315#15nmos@468_poly-left net@6293#3contact@2390_metal-1-polysilicon-1 gnd NMOS L=0.35U W=1.75U AS=1.608P AD=1.914P PS=4.462U PD=3.937U
Mnmos@469 gnd D1#0nmos@469_poly-left net@6303 gnd NMOS L=0.35U W=1.75U AS=1.914P AD=6.931P PS=3.937U PD=17.068U
Mnmos@470 net@6303 net@6315#2nmos@470_poly-left net@6314 gnd NMOS L=0.35U W=1.75U AS=1.914P AD=1.914P PS=3.937U PD=3.937U
Mnmos@471 net@6297 net@6304#12nmos@471_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=6.931P AD=1.991P PS=17.068U PD=5.775U
Mnmos@472 net@6314 S0#2nmos@472_poly-left net@6304 gnd NMOS L=0.35U W=1.75U AS=1.608P AD=1.914P PS=4.462U PD=3.937U
Mnmos@473 gnd D2#0nmos@473_poly-left net@6339 gnd NMOS L=0.35U W=1.75U AS=1.914P AD=6.931P PS=3.937U PD=17.068U
Mnmos@474 net@6339 S1#2nmos@474_poly-left net@6349 gnd NMOS L=0.35U W=1.75U AS=1.914P AD=1.914P PS=3.937U PD=3.937U
Mnmos@475 net@6333 net@6340#12nmos@475_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=6.931P AD=1.991P PS=17.068U PD=5.775U
Mnmos@476 net@6349 net@6360#2nmos@476_poly-left net@6340 gnd NMOS L=0.35U W=1.75U AS=1.608P AD=1.914P PS=4.462U PD=3.937U
Mnmos@477 gnd D3#3nmos@477_poly-left net@6429 gnd NMOS L=0.35U W=1.75U AS=1.914P AD=6.931P PS=3.937U PD=17.068U
Mnmos@478 net@6429 S1#6nmos@478_poly-left net@6436 gnd NMOS L=0.35U W=1.75U AS=1.914P AD=1.914P PS=3.937U PD=3.937U
Mnmos@479 net@6404#4contact@2430_metal-1-n-act net@6420#2nmos@479_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=6.931P AD=1.991P PS=17.068U PD=5.775U
Mnmos@480 net@6436 S0#7nmos@480_poly-left net@6420#3contact@2438_metal-1-polysilicon-1 gnd NMOS L=0.35U W=1.75U AS=1.608P AD=1.914P PS=4.462U PD=3.937U
Mnmos@481 net@6315#3contact@2440_metal-1-p-act S1#13nmos@481_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=6.931P AD=1.991P PS=17.068U PD=5.775U
Mnmos@482 net@6360#3contact@2421_metal-1-polysilicon-1 S0#12nmos@482_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=6.931P AD=1.991P PS=17.068U PD=5.775U
Mnmos@483 gnd net@6694 net@6609 gnd NMOS L=0.35U W=1.75U AS=1.378P AD=6.931P PS=3.675U PD=17.068U
Mnmos@484 net@6609 net@6596#6nmos@484_poly-left gnd gnd NMOS L=0.35U W=1.75U AS=6.931P AD=1.378P PS=17.068U PD=3.675U
Mnmos@485 net@6668 net@6609#13nmos@485_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=6.931P AD=1.991P PS=17.068U PD=5.775U
Mnmos@486 gnd net@6632#4nmos@486_poly-left net@6609 gnd NMOS L=0.35U W=1.75U AS=1.378P AD=6.931P PS=3.675U PD=17.068U
Mnmos@487 net@6609 net@6703#2nmos@487_poly-left gnd gnd NMOS L=0.35U W=1.75U AS=6.931P AD=1.378P PS=17.068U PD=3.675U
Mnmos@488 gnd D4#3nmos@488_poly-left net@6865 gnd NMOS L=0.35U W=1.75U AS=1.914P AD=6.931P PS=3.937U PD=17.068U
Mnmos@489 net@6865 net@6659#18nmos@489_poly-left net@6875 gnd NMOS L=0.35U W=1.75U AS=1.914P AD=1.914P PS=3.937U PD=3.937U
Mnmos@490 net@6694#3contact@2477_metal-1-polysilicon-1 net@6592#2nmos@490_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=6.931P AD=1.991P PS=17.068U PD=5.775U
Mnmos@491 net@6875 net@6614#15nmos@491_poly-left net@6592#3contact@2508_metal-1-polysilicon-1 gnd NMOS L=0.35U W=1.75U AS=1.608P AD=1.914P PS=4.462U PD=3.937U
Mnmos@492 gnd D5#0nmos@492_poly-left net@6602 gnd NMOS L=0.35U W=1.75U AS=1.914P AD=6.931P PS=3.937U PD=17.068U
Mnmos@493 net@6602 net@6614#2nmos@493_poly-left net@6613 gnd NMOS L=0.35U W=1.75U AS=1.914P AD=1.914P PS=3.937U PD=3.937U
Mnmos@494 net@6596 net@6603#12nmos@494_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=6.931P AD=1.991P PS=17.068U PD=5.775U
Mnmos@495 net@6613 S0#20nmos@495_poly-left net@6603 gnd NMOS L=0.35U W=1.75U AS=1.608P AD=1.914P PS=4.462U PD=3.937U
Mnmos@496 gnd D6#0nmos@496_poly-left net@6638 gnd NMOS L=0.35U W=1.75U AS=1.914P AD=6.931P PS=3.937U PD=17.068U
Mnmos@497 net@6638 S1#19nmos@497_poly-left net@6648 gnd NMOS L=0.35U W=1.75U AS=1.914P AD=1.914P PS=3.937U PD=3.937U
Mnmos@498 net@6632 net@6639#12nmos@498_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=6.931P AD=1.991P PS=17.068U PD=5.775U
Mnmos@499 net@6648 net@6659#2nmos@499_poly-left net@6639 gnd NMOS L=0.35U W=1.75U AS=1.608P AD=1.914P PS=4.462U PD=3.937U
Mnmos@500 gnd D7#3nmos@500_poly-left net@6728 gnd NMOS L=0.35U W=1.75U AS=1.914P AD=6.931P PS=3.937U PD=17.068U
Mnmos@501 net@6728 S1#23nmos@501_poly-left net@6735 gnd NMOS L=0.35U W=1.75U AS=1.914P AD=1.914P PS=3.937U PD=3.937U
Mnmos@502 net@6703#4contact@2548_metal-1-n-act net@6719#2nmos@502_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=6.931P AD=1.991P PS=17.068U PD=5.775U
Mnmos@503 net@6735 S0#25nmos@503_poly-left net@6719#3contact@2556_metal-1-polysilicon-1 gnd NMOS L=0.35U W=1.75U AS=1.608P AD=1.914P PS=4.462U PD=3.937U
Mnmos@504 net@6614#3contact@2558_metal-1-p-act S1#30nmos@504_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=6.931P AD=1.991P PS=17.068U PD=5.775U
Mnmos@505 net@6659#3contact@2539_metal-1-polysilicon-1 S0#30nmos@505_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=6.931P AD=1.991P PS=17.068U PD=5.775U
Mnmos@506 gnd net@6993 net@6908 gnd NMOS L=0.35U W=1.75U AS=1.378P AD=6.931P PS=3.675U PD=17.068U
Mnmos@507 net@6908 net@6895#6nmos@507_poly-left gnd gnd NMOS L=0.35U W=1.75U AS=6.931P AD=1.378P PS=17.068U PD=3.675U
Mnmos@508 net@6967 net@6908#13nmos@508_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=6.931P AD=1.991P PS=17.068U PD=5.775U
Mnmos@509 gnd net@6931#4nmos@509_poly-left net@6908 gnd NMOS L=0.35U W=1.75U AS=1.378P AD=6.931P PS=3.675U PD=17.068U
Mnmos@510 net@6908 net@7002#2nmos@510_poly-left gnd gnd NMOS L=0.35U W=1.75U AS=6.931P AD=1.378P PS=17.068U PD=3.675U
Mnmos@511 gnd D8#3nmos@511_poly-left net@7164 gnd NMOS L=0.35U W=1.75U AS=1.914P AD=6.931P PS=3.937U PD=17.068U
Mnmos@512 net@7164 net@6958#18nmos@512_poly-left net@7174 gnd NMOS L=0.35U W=1.75U AS=1.914P AD=1.914P PS=3.937U PD=3.937U
Mnmos@513 net@6993#3contact@2595_metal-1-polysilicon-1 net@6891#2nmos@513_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=6.931P AD=1.991P PS=17.068U PD=5.775U
Mnmos@514 net@7174 net@6913#15nmos@514_poly-left net@6891#3contact@2626_metal-1-polysilicon-1 gnd NMOS L=0.35U W=1.75U AS=1.608P AD=1.914P PS=4.462U PD=3.937U
Mnmos@515 gnd D9#0nmos@515_poly-left net@6901 gnd NMOS L=0.35U W=1.75U AS=1.914P AD=6.931P PS=3.937U PD=17.068U
Mnmos@516 net@6901 net@6913#2nmos@516_poly-left net@6912 gnd NMOS L=0.35U W=1.75U AS=1.914P AD=1.914P PS=3.937U PD=3.937U
Mnmos@517 net@6895 net@6902#12nmos@517_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=6.931P AD=1.991P PS=17.068U PD=5.775U
Mnmos@518 net@6912 S0#38nmos@518_poly-left net@6902 gnd NMOS L=0.35U W=1.75U AS=1.608P AD=1.914P PS=4.462U PD=3.937U
Mnmos@519 gnd D10#0nmos@519_poly-left net@6937 gnd NMOS L=0.35U W=1.75U AS=1.914P AD=6.931P PS=3.937U PD=17.068U
Mnmos@520 net@6937 S1#36nmos@520_poly-left net@6947 gnd NMOS L=0.35U W=1.75U AS=1.914P AD=1.914P PS=3.937U PD=3.937U
Mnmos@521 net@6931 net@6938#12nmos@521_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=6.931P AD=1.991P PS=17.068U PD=5.775U
Mnmos@522 net@6947 net@6958#2nmos@522_poly-left net@6938 gnd NMOS L=0.35U W=1.75U AS=1.608P AD=1.914P PS=4.462U PD=3.937U
Mnmos@523 gnd D11#3nmos@523_poly-left net@7027 gnd NMOS L=0.35U W=1.75U AS=1.914P AD=6.931P PS=3.937U PD=17.068U
Mnmos@524 net@7027 S1#40nmos@524_poly-left net@7034 gnd NMOS L=0.35U W=1.75U AS=1.914P AD=1.914P PS=3.937U PD=3.937U
Mnmos@525 net@7002#4contact@2666_metal-1-n-act net@7018#2nmos@525_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=6.931P AD=1.991P PS=17.068U PD=5.775U
Mnmos@526 net@7034 S0#43nmos@526_poly-left net@7018#3contact@2674_metal-1-polysilicon-1 gnd NMOS L=0.35U W=1.75U AS=1.608P AD=1.914P PS=4.462U PD=3.937U
Mnmos@527 net@6913#3contact@2676_metal-1-p-act S1#47nmos@527_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=6.931P AD=1.991P PS=17.068U PD=5.775U
Mnmos@528 net@6958#3contact@2657_metal-1-polysilicon-1 S0#48nmos@528_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=6.931P AD=1.991P PS=17.068U PD=5.775U
Mnmos@529 gnd net@7292 net@7207 gnd NMOS L=0.35U W=1.75U AS=1.378P AD=6.931P PS=3.675U PD=17.068U
Mnmos@530 net@7207 net@7194#6nmos@530_poly-left gnd gnd NMOS L=0.35U W=1.75U AS=6.931P AD=1.378P PS=17.068U PD=3.675U
Mnmos@531 net@7266 net@7207#13nmos@531_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=6.931P AD=1.991P PS=17.068U PD=5.775U
Mnmos@532 gnd net@7230#4nmos@532_poly-left net@7207 gnd NMOS L=0.35U W=1.75U AS=1.378P AD=6.931P PS=3.675U PD=17.068U
Mnmos@533 net@7207 net@7301#2nmos@533_poly-left gnd gnd NMOS L=0.35U W=1.75U AS=6.931P AD=1.378P PS=17.068U PD=3.675U
Mnmos@534 gnd D12#3nmos@534_poly-left net@7463 gnd NMOS L=0.35U W=1.75U AS=1.914P AD=6.931P PS=3.937U PD=17.068U
Mnmos@535 net@7463 net@7257#18nmos@535_poly-left net@7473 gnd NMOS L=0.35U W=1.75U AS=1.914P AD=1.914P PS=3.937U PD=3.937U
Mnmos@536 net@7292#3contact@2713_metal-1-polysilicon-1 net@7190#2nmos@536_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=6.931P AD=1.991P PS=17.068U PD=5.775U
Mnmos@537 net@7473 net@7212#15nmos@537_poly-left net@7190#3contact@2744_metal-1-polysilicon-1 gnd NMOS L=0.35U W=1.75U AS=1.608P AD=1.914P PS=4.462U PD=3.937U
Mnmos@538 gnd D13#0nmos@538_poly-left net@7200 gnd NMOS L=0.35U W=1.75U AS=1.914P AD=6.931P PS=3.937U PD=17.068U
Mnmos@539 net@7200 net@7212#2nmos@539_poly-left net@7211 gnd NMOS L=0.35U W=1.75U AS=1.914P AD=1.914P PS=3.937U PD=3.937U
Mnmos@540 net@7194 net@7201#12nmos@540_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=6.931P AD=1.991P PS=17.068U PD=5.775U
Mnmos@541 net@7211 S0#56nmos@541_poly-left net@7201 gnd NMOS L=0.35U W=1.75U AS=1.608P AD=1.914P PS=4.462U PD=3.937U
Mnmos@542 gnd D14#0nmos@542_poly-left net@7236 gnd NMOS L=0.35U W=1.75U AS=1.914P AD=6.931P PS=3.937U PD=17.068U
Mnmos@543 net@7236 S1#53nmos@543_poly-left net@7246 gnd NMOS L=0.35U W=1.75U AS=1.914P AD=1.914P PS=3.937U PD=3.937U
Mnmos@544 net@7230 net@7237#12nmos@544_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=6.931P AD=1.991P PS=17.068U PD=5.775U
Mnmos@545 net@7246 net@7257#2nmos@545_poly-left net@7237 gnd NMOS L=0.35U W=1.75U AS=1.608P AD=1.914P PS=4.462U PD=3.937U
Mnmos@546 gnd D15#3nmos@546_poly-left net@7326 gnd NMOS L=0.35U W=1.75U AS=1.914P AD=6.931P PS=3.937U PD=17.068U
Mnmos@547 net@7326 S1#57nmos@547_poly-left net@7333 gnd NMOS L=0.35U W=1.75U AS=1.914P AD=1.914P PS=3.937U PD=3.937U
Mnmos@548 net@7301#4contact@2784_metal-1-n-act net@7317#2nmos@548_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=6.931P AD=1.991P PS=17.068U PD=5.775U
Mnmos@549 net@7333 S0#61nmos@549_poly-left net@7317#3contact@2792_metal-1-polysilicon-1 gnd NMOS L=0.35U W=1.75U AS=1.608P AD=1.914P PS=4.462U PD=3.937U
Mnmos@550 net@7212#3contact@2794_metal-1-p-act S1#64nmos@550_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=6.931P AD=1.991P PS=17.068U PD=5.775U
Mnmos@551 net@7257#3contact@2775_metal-1-polysilicon-1 S0#66nmos@551_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=6.931P AD=1.991P PS=17.068U PD=5.775U
Mnmos@552 gnd net@7591 net@7506 gnd NMOS L=0.35U W=1.75U AS=1.378P AD=6.931P PS=3.675U PD=17.068U
Mnmos@553 net@7506 net@7493#6nmos@553_poly-left gnd gnd NMOS L=0.35U W=1.75U AS=6.931P AD=1.378P PS=17.068U PD=3.675U
Mnmos@554 Vout net@7506#13nmos@554_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=6.931P AD=1.991P PS=17.068U PD=5.775U
Mnmos@555 gnd net@7529#4nmos@555_poly-left net@7506 gnd NMOS L=0.35U W=1.75U AS=1.378P AD=6.931P PS=3.675U PD=17.068U
Mnmos@556 net@7506 net@7600#2nmos@556_poly-left gnd gnd NMOS L=0.35U W=1.75U AS=6.931P AD=1.378P PS=17.068U PD=3.675U
Mnmos@557 gnd net@6369#7nmos@557_poly-left net@7762 gnd NMOS L=0.35U W=1.75U AS=1.914P AD=6.931P PS=3.937U PD=17.068U
Mnmos@558 net@7762 net@7556#18nmos@558_poly-left net@7772 gnd NMOS L=0.35U W=1.75U AS=1.914P AD=1.914P PS=3.937U PD=3.937U
Mnmos@559 net@7591#3contact@2831_metal-1-polysilicon-1 net@7489#2nmos@559_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=6.931P AD=1.991P PS=17.068U PD=5.775U
Mnmos@560 net@7772 net@7511#15nmos@560_poly-left net@7489#3contact@2862_metal-1-polysilicon-1 gnd NMOS L=0.35U W=1.75U AS=1.608P AD=1.914P PS=4.462U PD=3.937U
Mnmos@561 gnd net@6668#4nmos@561_poly-left net@7499 gnd NMOS L=0.35U W=1.75U AS=1.914P AD=6.931P PS=3.937U PD=17.068U
Mnmos@562 net@7499 net@7511#2nmos@562_poly-left net@7510 gnd NMOS L=0.35U W=1.75U AS=1.914P AD=1.914P PS=3.937U PD=3.937U
Mnmos@563 net@7493 net@7500#12nmos@563_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=6.931P AD=1.991P PS=17.068U PD=5.775U
Mnmos@564 net@7510 S2#2nmos@564_poly-left net@7500 gnd NMOS L=0.35U W=1.75U AS=1.608P AD=1.914P PS=4.462U PD=3.937U
Mnmos@565 gnd net@6967#4nmos@565_poly-left net@7535 gnd NMOS L=0.35U W=1.75U AS=1.914P AD=6.931P PS=3.937U PD=17.068U
Mnmos@566 net@7535 S3#2nmos@566_poly-left net@7545 gnd NMOS L=0.35U W=1.75U AS=1.914P AD=1.914P PS=3.937U PD=3.937U
Mnmos@567 net@7529 net@7536#12nmos@567_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=6.931P AD=1.991P PS=17.068U PD=5.775U
Mnmos@568 net@7545 net@7556#2nmos@568_poly-left net@7536 gnd NMOS L=0.35U W=1.75U AS=1.608P AD=1.914P PS=4.462U PD=3.937U
Mnmos@569 gnd net@7266#7nmos@569_poly-left net@7625 gnd NMOS L=0.35U W=1.75U AS=1.914P AD=6.931P PS=3.937U PD=17.068U
Mnmos@570 net@7625 S3#6nmos@570_poly-left net@7632 gnd NMOS L=0.35U W=1.75U AS=1.914P AD=1.914P PS=3.937U PD=3.937U
Mnmos@571 net@7600#4contact@2902_metal-1-n-act net@7616#2nmos@571_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=6.931P AD=1.991P PS=17.068U PD=5.775U
Mnmos@572 net@7632 S2#7nmos@572_poly-left net@7616#3contact@2910_metal-1-polysilicon-1 gnd NMOS L=0.35U W=1.75U AS=1.608P AD=1.914P PS=4.462U PD=3.937U
Mnmos@573 net@7511#3contact@2912_metal-1-p-act S3#14nmos@573_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=6.931P AD=1.991P PS=17.068U PD=5.775U
Mnmos@574 net@7556#3contact@2893_metal-1-polysilicon-1 S2#12nmos@574_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=6.931P AD=1.991P PS=17.068U PD=5.775U
Mpmos@460 net@6413 net@6297#4pmos@460_poly-right net@6385 vdd PMOS L=0.35U W=1.75U AS=1.914P AD=1.914P PS=3.937U PD=3.937U
Mpmos@461 vdd net@6310#11pmos@461_poly-right net@6369 vdd PMOS L=0.35U W=1.75U AS=1.991P AD=6.223P PS=5.775U PD=13.475U
Mpmos@462 vdd net@6395#2pmos@462_poly-right net@6413 vdd PMOS L=0.35U W=1.75U AS=1.914P AD=6.223P PS=3.937U PD=13.475U
Mpmos@463 net@6383 net@6404 net@6310 vdd PMOS L=0.35U W=1.75U AS=1.378P AD=1.914P PS=3.675U PD=3.937U
Mpmos@464 net@6385 net@6333#6pmos@464_poly-right net@6383 vdd PMOS L=0.35U W=1.75U AS=1.914P AD=1.914P PS=3.937U PD=3.937U
Mpmos@465 vdd net@6360#16pmos@465_poly-right net@6293#3contact@2390_metal-1-polysilicon-1 vdd PMOS L=0.35U W=1.75U AS=1.608P AD=6.223P PS=4.462U PD=13.475U
Mpmos@466 net@6293#3contact@2390_metal-1-polysilicon-1 D0#5pmos@466_poly-right vdd vdd PMOS L=0.35U W=1.75U AS=6.223P AD=1.608P PS=13.475U PD=4.462U
Mpmos@467 vdd net@6293 net@6395#3contact@2359_metal-1-polysilicon-1 vdd PMOS L=0.35U W=1.75U AS=1.991P AD=6.223P PS=5.775U PD=13.475U
Mpmos@468 net@6293#3contact@2390_metal-1-polysilicon-1 net@6315#13pmos@468_poly-right vdd vdd PMOS L=0.35U W=1.75U AS=6.223P AD=1.608P PS=13.475U PD=4.462U
Mpmos@469 vdd net@6315 net@6304 vdd PMOS L=0.35U W=1.75U AS=1.608P AD=6.223P PS=4.462U PD=13.475U
Mpmos@470 net@6304 D1#2pmos@470_poly-right vdd vdd PMOS L=0.35U W=1.75U AS=6.223P AD=1.608P PS=13.475U PD=4.462U
Mpmos@471 vdd net@6304#10pmos@471_poly-right net@6297 vdd PMOS L=0.35U W=1.75U AS=1.991P AD=6.223P PS=5.775U PD=13.475U
Mpmos@472 net@6304 S0#0pmos@472_poly-right vdd vdd PMOS L=0.35U W=1.75U AS=6.223P AD=1.608P PS=13.475U PD=4.462U
Mpmos@473 vdd S1#0pmos@473_poly-right net@6340 vdd PMOS L=0.35U W=1.75U AS=1.608P AD=6.223P PS=4.462U PD=13.475U
Mpmos@474 net@6340 D2#2pmos@474_poly-right vdd vdd PMOS L=0.35U W=1.75U AS=6.223P AD=1.608P PS=13.475U PD=4.462U
Mpmos@475 vdd net@6340#10pmos@475_poly-right net@6333 vdd PMOS L=0.35U W=1.75U AS=1.991P AD=6.223P PS=5.775U PD=13.475U
Mpmos@476 net@6340 net@6360 vdd vdd PMOS L=0.35U W=1.75U AS=6.223P AD=1.608P PS=13.475U PD=4.462U
Mpmos@477 vdd S1#4pmos@477_poly-right net@6420#3contact@2438_metal-1-polysilicon-1 vdd PMOS L=0.35U W=1.75U AS=1.608P AD=6.223P PS=4.462U PD=13.475U
Mpmos@478 net@6420#3contact@2438_metal-1-polysilicon-1 D3#5pmos@478_poly-right vdd vdd PMOS L=0.35U W=1.75U AS=6.223P AD=1.608P PS=13.475U PD=4.462U
Mpmos@479 vdd net@6420 net@6404#4contact@2430_metal-1-n-act vdd PMOS L=0.35U W=1.75U AS=1.991P AD=6.223P PS=5.775U PD=13.475U
Mpmos@480 net@6420#3contact@2438_metal-1-polysilicon-1 S0#5pmos@480_poly-right vdd vdd PMOS L=0.35U W=1.75U AS=6.223P AD=1.608P PS=13.475U PD=4.462U
Mpmos@481 vdd S1#11pmos@481_poly-right net@6315#3contact@2440_metal-1-p-act vdd PMOS L=0.35U W=1.75U AS=1.991P AD=6.223P PS=5.775U PD=13.475U
Mpmos@482 vdd S0#10pmos@482_poly-right net@6360#3contact@2421_metal-1-polysilicon-1 vdd PMOS L=0.35U W=1.75U AS=1.991P AD=6.223P PS=5.775U PD=13.475U
Mpmos@483 net@6712 net@6596#4pmos@483_poly-right net@6684 vdd PMOS L=0.35U W=1.75U AS=1.914P AD=1.914P PS=3.937U PD=3.937U
Mpmos@484 vdd net@6609#11pmos@484_poly-right net@6668 vdd PMOS L=0.35U W=1.75U AS=1.991P AD=6.223P PS=5.775U PD=13.475U
Mpmos@485 vdd net@6694#2pmos@485_poly-right net@6712 vdd PMOS L=0.35U W=1.75U AS=1.914P AD=6.223P PS=3.937U PD=13.475U
Mpmos@486 net@6682 net@6703 net@6609 vdd PMOS L=0.35U W=1.75U AS=1.378P AD=1.914P PS=3.675U PD=3.937U
Mpmos@487 net@6684 net@6632#6pmos@487_poly-right net@6682 vdd PMOS L=0.35U W=1.75U AS=1.914P AD=1.914P PS=3.937U PD=3.937U
Mpmos@488 vdd net@6659#16pmos@488_poly-right net@6592#3contact@2508_metal-1-polysilicon-1 vdd PMOS L=0.35U W=1.75U AS=1.608P AD=6.223P PS=4.462U PD=13.475U
Mpmos@489 net@6592#3contact@2508_metal-1-polysilicon-1 D4#5pmos@489_poly-right vdd vdd PMOS L=0.35U W=1.75U AS=6.223P AD=1.608P PS=13.475U PD=4.462U
Mpmos@490 vdd net@6592 net@6694#3contact@2477_metal-1-polysilicon-1 vdd PMOS L=0.35U W=1.75U AS=1.991P AD=6.223P PS=5.775U PD=13.475U
Mpmos@491 net@6592#3contact@2508_metal-1-polysilicon-1 net@6614#13pmos@491_poly-right vdd vdd PMOS L=0.35U W=1.75U AS=6.223P AD=1.608P PS=13.475U PD=4.462U
Mpmos@492 vdd net@6614 net@6603 vdd PMOS L=0.35U W=1.75U AS=1.608P AD=6.223P PS=4.462U PD=13.475U
Mpmos@493 net@6603 D5#2pmos@493_poly-right vdd vdd PMOS L=0.35U W=1.75U AS=6.223P AD=1.608P PS=13.475U PD=4.462U
Mpmos@494 vdd net@6603#10pmos@494_poly-right net@6596 vdd PMOS L=0.35U W=1.75U AS=1.991P AD=6.223P PS=5.775U PD=13.475U
Mpmos@495 net@6603 S0#18pmos@495_poly-right vdd vdd PMOS L=0.35U W=1.75U AS=6.223P AD=1.608P PS=13.475U PD=4.462U
Mpmos@496 vdd S1#17pmos@496_poly-right net@6639 vdd PMOS L=0.35U W=1.75U AS=1.608P AD=6.223P PS=4.462U PD=13.475U
Mpmos@497 net@6639 D6#2pmos@497_poly-right vdd vdd PMOS L=0.35U W=1.75U AS=6.223P AD=1.608P PS=13.475U PD=4.462U
Mpmos@498 vdd net@6639#10pmos@498_poly-right net@6632 vdd PMOS L=0.35U W=1.75U AS=1.991P AD=6.223P PS=5.775U PD=13.475U
Mpmos@499 net@6639 net@6659 vdd vdd PMOS L=0.35U W=1.75U AS=6.223P AD=1.608P PS=13.475U PD=4.462U
Mpmos@500 vdd S1#21pmos@500_poly-right net@6719#3contact@2556_metal-1-polysilicon-1 vdd PMOS L=0.35U W=1.75U AS=1.608P AD=6.223P PS=4.462U PD=13.475U
Mpmos@501 net@6719#3contact@2556_metal-1-polysilicon-1 D7#5pmos@501_poly-right vdd vdd PMOS L=0.35U W=1.75U AS=6.223P AD=1.608P PS=13.475U PD=4.462U
Mpmos@502 vdd net@6719 net@6703#4contact@2548_metal-1-n-act vdd PMOS L=0.35U W=1.75U AS=1.991P AD=6.223P PS=5.775U PD=13.475U
Mpmos@503 net@6719#3contact@2556_metal-1-polysilicon-1 S0#23pmos@503_poly-right vdd vdd PMOS L=0.35U W=1.75U AS=6.223P AD=1.608P PS=13.475U PD=4.462U
Mpmos@504 vdd S1#28pmos@504_poly-right net@6614#3contact@2558_metal-1-p-act vdd PMOS L=0.35U W=1.75U AS=1.991P AD=6.223P PS=5.775U PD=13.475U
Mpmos@505 vdd S0#28pmos@505_poly-right net@6659#3contact@2539_metal-1-polysilicon-1 vdd PMOS L=0.35U W=1.75U AS=1.991P AD=6.223P PS=5.775U PD=13.475U
Mpmos@506 net@7011 net@6895#4pmos@506_poly-right net@6983 vdd PMOS L=0.35U W=1.75U AS=1.914P AD=1.914P PS=3.937U PD=3.937U
Mpmos@507 vdd net@6908#11pmos@507_poly-right net@6967 vdd PMOS L=0.35U W=1.75U AS=1.991P AD=6.223P PS=5.775U PD=13.475U
Mpmos@508 vdd net@6993#2pmos@508_poly-right net@7011 vdd PMOS L=0.35U W=1.75U AS=1.914P AD=6.223P PS=3.937U PD=13.475U
Mpmos@509 net@6981 net@7002 net@6908 vdd PMOS L=0.35U W=1.75U AS=1.378P AD=1.914P PS=3.675U PD=3.937U
Mpmos@510 net@6983 net@6931#6pmos@510_poly-right net@6981 vdd PMOS L=0.35U W=1.75U AS=1.914P AD=1.914P PS=3.937U PD=3.937U
Mpmos@511 vdd net@6958#16pmos@511_poly-right net@6891#3contact@2626_metal-1-polysilicon-1 vdd PMOS L=0.35U W=1.75U AS=1.608P AD=6.223P PS=4.462U PD=13.475U
Mpmos@512 net@6891#3contact@2626_metal-1-polysilicon-1 D8#5pmos@512_poly-right vdd vdd PMOS L=0.35U W=1.75U AS=6.223P AD=1.608P PS=13.475U PD=4.462U
Mpmos@513 vdd net@6891 net@6993#3contact@2595_metal-1-polysilicon-1 vdd PMOS L=0.35U W=1.75U AS=1.991P AD=6.223P PS=5.775U PD=13.475U
Mpmos@514 net@6891#3contact@2626_metal-1-polysilicon-1 net@6913#13pmos@514_poly-right vdd vdd PMOS L=0.35U W=1.75U AS=6.223P AD=1.608P PS=13.475U PD=4.462U
Mpmos@515 vdd net@6913 net@6902 vdd PMOS L=0.35U W=1.75U AS=1.608P AD=6.223P PS=4.462U PD=13.475U
Mpmos@516 net@6902 D9#2pmos@516_poly-right vdd vdd PMOS L=0.35U W=1.75U AS=6.223P AD=1.608P PS=13.475U PD=4.462U
Mpmos@517 vdd net@6902#10pmos@517_poly-right net@6895 vdd PMOS L=0.35U W=1.75U AS=1.991P AD=6.223P PS=5.775U PD=13.475U
Mpmos@518 net@6902 S0#36pmos@518_poly-right vdd vdd PMOS L=0.35U W=1.75U AS=6.223P AD=1.608P PS=13.475U PD=4.462U
Mpmos@519 vdd S1#34pmos@519_poly-right net@6938 vdd PMOS L=0.35U W=1.75U AS=1.608P AD=6.223P PS=4.462U PD=13.475U
Mpmos@520 net@6938 D10#2pmos@520_poly-right vdd vdd PMOS L=0.35U W=1.75U AS=6.223P AD=1.608P PS=13.475U PD=4.462U
Mpmos@521 vdd net@6938#10pmos@521_poly-right net@6931 vdd PMOS L=0.35U W=1.75U AS=1.991P AD=6.223P PS=5.775U PD=13.475U
Mpmos@522 net@6938 net@6958 vdd vdd PMOS L=0.35U W=1.75U AS=6.223P AD=1.608P PS=13.475U PD=4.462U
Mpmos@523 vdd S1#38pmos@523_poly-right net@7018#3contact@2674_metal-1-polysilicon-1 vdd PMOS L=0.35U W=1.75U AS=1.608P AD=6.223P PS=4.462U PD=13.475U
Mpmos@524 net@7018#3contact@2674_metal-1-polysilicon-1 D11#5pmos@524_poly-right vdd vdd PMOS L=0.35U W=1.75U AS=6.223P AD=1.608P PS=13.475U PD=4.462U
Mpmos@525 vdd net@7018 net@7002#4contact@2666_metal-1-n-act vdd PMOS L=0.35U W=1.75U AS=1.991P AD=6.223P PS=5.775U PD=13.475U
Mpmos@526 net@7018#3contact@2674_metal-1-polysilicon-1 S0#41pmos@526_poly-right vdd vdd PMOS L=0.35U W=1.75U AS=6.223P AD=1.608P PS=13.475U PD=4.462U
Mpmos@527 vdd S1#45pmos@527_poly-right net@6913#3contact@2676_metal-1-p-act vdd PMOS L=0.35U W=1.75U AS=1.991P AD=6.223P PS=5.775U PD=13.475U
Mpmos@528 vdd S0#46pmos@528_poly-right net@6958#3contact@2657_metal-1-polysilicon-1 vdd PMOS L=0.35U W=1.75U AS=1.991P AD=6.223P PS=5.775U PD=13.475U
Mpmos@529 net@7310 net@7194#4pmos@529_poly-right net@7282 vdd PMOS L=0.35U W=1.75U AS=1.914P AD=1.914P PS=3.937U PD=3.937U
Mpmos@530 vdd net@7207#11pmos@530_poly-right net@7266 vdd PMOS L=0.35U W=1.75U AS=1.991P AD=6.223P PS=5.775U PD=13.475U
Mpmos@531 vdd net@7292#2pmos@531_poly-right net@7310 vdd PMOS L=0.35U W=1.75U AS=1.914P AD=6.223P PS=3.937U PD=13.475U
Mpmos@532 net@7280 net@7301 net@7207 vdd PMOS L=0.35U W=1.75U AS=1.378P AD=1.914P PS=3.675U PD=3.937U
Mpmos@533 net@7282 net@7230#6pmos@533_poly-right net@7280 vdd PMOS L=0.35U W=1.75U AS=1.914P AD=1.914P PS=3.937U PD=3.937U
Mpmos@534 vdd net@7257#16pmos@534_poly-right net@7190#3contact@2744_metal-1-polysilicon-1 vdd PMOS L=0.35U W=1.75U AS=1.608P AD=6.223P PS=4.462U PD=13.475U
Mpmos@535 net@7190#3contact@2744_metal-1-polysilicon-1 D12#5pmos@535_poly-right vdd vdd PMOS L=0.35U W=1.75U AS=6.223P AD=1.608P PS=13.475U PD=4.462U
Mpmos@536 vdd net@7190 net@7292#3contact@2713_metal-1-polysilicon-1 vdd PMOS L=0.35U W=1.75U AS=1.991P AD=6.223P PS=5.775U PD=13.475U
Mpmos@537 net@7190#3contact@2744_metal-1-polysilicon-1 net@7212#13pmos@537_poly-right vdd vdd PMOS L=0.35U W=1.75U AS=6.223P AD=1.608P PS=13.475U PD=4.462U
Mpmos@538 vdd net@7212 net@7201 vdd PMOS L=0.35U W=1.75U AS=1.608P AD=6.223P PS=4.462U PD=13.475U
Mpmos@539 net@7201 D13#2pmos@539_poly-right vdd vdd PMOS L=0.35U W=1.75U AS=6.223P AD=1.608P PS=13.475U PD=4.462U
Mpmos@540 vdd net@7201#10pmos@540_poly-right net@7194 vdd PMOS L=0.35U W=1.75U AS=1.991P AD=6.223P PS=5.775U PD=13.475U
Mpmos@541 net@7201 S0#54pmos@541_poly-right vdd vdd PMOS L=0.35U W=1.75U AS=6.223P AD=1.608P PS=13.475U PD=4.462U
Mpmos@542 vdd S1#51pmos@542_poly-right net@7237 vdd PMOS L=0.35U W=1.75U AS=1.608P AD=6.223P PS=4.462U PD=13.475U
Mpmos@543 net@7237 D14#2pmos@543_poly-right vdd vdd PMOS L=0.35U W=1.75U AS=6.223P AD=1.608P PS=13.475U PD=4.462U
Mpmos@544 vdd net@7237#10pmos@544_poly-right net@7230 vdd PMOS L=0.35U W=1.75U AS=1.991P AD=6.223P PS=5.775U PD=13.475U
Mpmos@545 net@7237 net@7257 vdd vdd PMOS L=0.35U W=1.75U AS=6.223P AD=1.608P PS=13.475U PD=4.462U
Mpmos@546 vdd S1#55pmos@546_poly-right net@7317#3contact@2792_metal-1-polysilicon-1 vdd PMOS L=0.35U W=1.75U AS=1.608P AD=6.223P PS=4.462U PD=13.475U
Mpmos@547 net@7317#3contact@2792_metal-1-polysilicon-1 D15#5pmos@547_poly-right vdd vdd PMOS L=0.35U W=1.75U AS=6.223P AD=1.608P PS=13.475U PD=4.462U
Mpmos@548 vdd net@7317 net@7301#4contact@2784_metal-1-n-act vdd PMOS L=0.35U W=1.75U AS=1.991P AD=6.223P PS=5.775U PD=13.475U
Mpmos@549 net@7317#3contact@2792_metal-1-polysilicon-1 S0#59pmos@549_poly-right vdd vdd PMOS L=0.35U W=1.75U AS=6.223P AD=1.608P PS=13.475U PD=4.462U
Mpmos@550 vdd S1#62pmos@550_poly-right net@7212#3contact@2794_metal-1-p-act vdd PMOS L=0.35U W=1.75U AS=1.991P AD=6.223P PS=5.775U PD=13.475U
Mpmos@551 vdd S0#64pmos@551_poly-right net@7257#3contact@2775_metal-1-polysilicon-1 vdd PMOS L=0.35U W=1.75U AS=1.991P AD=6.223P PS=5.775U PD=13.475U
Mpmos@552 net@7609 net@7493#4pmos@552_poly-right net@7581 vdd PMOS L=0.35U W=1.75U AS=1.914P AD=1.914P PS=3.937U PD=3.937U
Mpmos@553 vdd net@7506#11pmos@553_poly-right Vout vdd PMOS L=0.35U W=1.75U AS=1.991P AD=6.223P PS=5.775U PD=13.475U
Mpmos@554 vdd net@7591#2pmos@554_poly-right net@7609 vdd PMOS L=0.35U W=1.75U AS=1.914P AD=6.223P PS=3.937U PD=13.475U
Mpmos@555 net@7579 net@7600 net@7506 vdd PMOS L=0.35U W=1.75U AS=1.378P AD=1.914P PS=3.675U PD=3.937U
Mpmos@556 net@7581 net@7529#6pmos@556_poly-right net@7579 vdd PMOS L=0.35U W=1.75U AS=1.914P AD=1.914P PS=3.937U PD=3.937U
Mpmos@557 vdd net@7556#16pmos@557_poly-right net@7489#3contact@2862_metal-1-polysilicon-1 vdd PMOS L=0.35U W=1.75U AS=1.608P AD=6.223P PS=4.462U PD=13.475U
Mpmos@558 net@7489#3contact@2862_metal-1-polysilicon-1 net@6369#9pmos@558_poly-right vdd vdd PMOS L=0.35U W=1.75U AS=6.223P AD=1.608P PS=13.475U PD=4.462U
Mpmos@559 vdd net@7489 net@7591#3contact@2831_metal-1-polysilicon-1 vdd PMOS L=0.35U W=1.75U AS=1.991P AD=6.223P PS=5.775U PD=13.475U
Mpmos@560 net@7489#3contact@2862_metal-1-polysilicon-1 net@7511#13pmos@560_poly-right vdd vdd PMOS L=0.35U W=1.75U AS=6.223P AD=1.608P PS=13.475U PD=4.462U
Mpmos@561 vdd net@7511 net@7500 vdd PMOS L=0.35U W=1.75U AS=1.608P AD=6.223P PS=4.462U PD=13.475U
Mpmos@562 net@7500 net@6668#6pmos@562_poly-right vdd vdd PMOS L=0.35U W=1.75U AS=6.223P AD=1.608P PS=13.475U PD=4.462U
Mpmos@563 vdd net@7500#10pmos@563_poly-right net@7493 vdd PMOS L=0.35U W=1.75U AS=1.991P AD=6.223P PS=5.775U PD=13.475U
Mpmos@564 net@7500 S2#0pmos@564_poly-right vdd vdd PMOS L=0.35U W=1.75U AS=6.223P AD=1.608P PS=13.475U PD=4.462U
Mpmos@565 vdd S3#0pmos@565_poly-right net@7536 vdd PMOS L=0.35U W=1.75U AS=1.608P AD=6.223P PS=4.462U PD=13.475U
Mpmos@566 net@7536 net@6967#6pmos@566_poly-right vdd vdd PMOS L=0.35U W=1.75U AS=6.223P AD=1.608P PS=13.475U PD=4.462U
Mpmos@567 vdd net@7536#10pmos@567_poly-right net@7529 vdd PMOS L=0.35U W=1.75U AS=1.991P AD=6.223P PS=5.775U PD=13.475U
Mpmos@568 net@7536 net@7556 vdd vdd PMOS L=0.35U W=1.75U AS=6.223P AD=1.608P PS=13.475U PD=4.462U
Mpmos@569 vdd S3#4pmos@569_poly-right net@7616#3contact@2910_metal-1-polysilicon-1 vdd PMOS L=0.35U W=1.75U AS=1.608P AD=6.223P PS=4.462U PD=13.475U
Mpmos@570 net@7616#3contact@2910_metal-1-polysilicon-1 net@7266#9pmos@570_poly-right vdd vdd PMOS L=0.35U W=1.75U AS=6.223P AD=1.608P PS=13.475U PD=4.462U
Mpmos@571 vdd net@7616 net@7600#4contact@2902_metal-1-n-act vdd PMOS L=0.35U W=1.75U AS=1.991P AD=6.223P PS=5.775U PD=13.475U
Mpmos@572 net@7616#3contact@2910_metal-1-polysilicon-1 S2#5pmos@572_poly-right vdd vdd PMOS L=0.35U W=1.75U AS=6.223P AD=1.608P PS=13.475U PD=4.462U
Mpmos@573 vdd S3#12pmos@573_poly-right net@7511#3contact@2912_metal-1-p-act vdd PMOS L=0.35U W=1.75U AS=1.991P AD=6.223P PS=5.775U PD=13.475U
Mpmos@574 vdd S2#10pmos@574_poly-right net@7556#3contact@2893_metal-1-polysilicon-1 vdd PMOS L=0.35U W=1.75U AS=1.991P AD=6.223P PS=5.775U PD=13.475U
** Extracted Parasitic Capacitors ***
C0 net@6310 0 7.637fF
C1 net@6395#3contact@2359_metal-1-polysilicon-1 0 5.15fF
C2 net@6369 0 19.742fF
C3 net@6297 0 10.126fF
C4 net@6333#5contact@2373_metal-1-polysilicon-1 0 5.094fF
C5 net@6404#1contact@2374_metal-1-polysilicon-1 0 7.35fF
C6 net@6293#3contact@2390_metal-1-polysilicon-1 0 7.135fF
C7 D0#0contact@2468_metal-1-metal-2 0 7.822fF
C8 net@6360#3contact@2421_metal-1-polysilicon-1 0 20.552fF
C9 net@6315#1contact@2403_metal-1-polysilicon-1 0 11.324fF
C10 net@6304 0 7.359fF
C11 D1#3contact@2393_metal-1-polysilicon-1 0 6.04fF
C12 S0#3contact@2405_metal-1-polysilicon-1 0 4.472fF
C13 net@6340 0 7.41fF
C14 D2#3contact@2409_metal-1-polysilicon-1 0 4.205fF
C15 net@6333 0 9.128fF
C16 S1 0 74.852fF
C17 net@6420#3contact@2438_metal-1-polysilicon-1 0 7.408fF
C18 D3 0 4.606fF
C19 net@6404#4contact@2430_metal-1-n-act 0 10.686fF
C20 S0 0 58.912fF
C21 net@6315#3contact@2440_metal-1-p-act 0 8.786fF
C22 D2 0 4.079fF
C23 D1 0 5.874fF
C24 D0 0 7.684fF
C25 net@6609 0 7.637fF
C26 net@6694#3contact@2477_metal-1-polysilicon-1 0 5.15fF
C27 net@6668 0 12.038fF
C28 net@6596 0 10.126fF
C29 net@6632#5contact@2491_metal-1-polysilicon-1 0 5.094fF
C30 net@6703#1contact@2492_metal-1-polysilicon-1 0 7.35fF
C31 net@6592#3contact@2508_metal-1-polysilicon-1 0 7.135fF
C32 D4#0contact@2586_metal-1-metal-2 0 7.822fF
C33 net@6659#3contact@2539_metal-1-polysilicon-1 0 20.552fF
C34 net@6614#1contact@2521_metal-1-polysilicon-1 0 11.324fF
C35 net@6603 0 7.359fF
C36 D5#3contact@2511_metal-1-polysilicon-1 0 6.04fF
C37 S0#21contact@2523_metal-1-polysilicon-1 0 4.472fF
C38 net@6639 0 7.41fF
C39 D6#3contact@2527_metal-1-polysilicon-1 0 4.205fF
C40 net@6632 0 9.128fF
C41 net@6719#3contact@2556_metal-1-polysilicon-1 0 7.408fF
C42 D7 0 4.606fF
C43 net@6703#4contact@2548_metal-1-n-act 0 10.686fF
C44 net@6614#3contact@2558_metal-1-p-act 0 8.786fF
C45 D6 0 4.079fF
C46 D5 0 5.874fF
C47 D4 0 7.684fF
C48 net@6908 0 7.637fF
C49 net@6993#3contact@2595_metal-1-polysilicon-1 0 5.15fF
C50 net@6967 0 14.915fF
C51 net@6895 0 10.126fF
C52 net@6931#5contact@2609_metal-1-polysilicon-1 0 5.094fF
C53 net@7002#1contact@2610_metal-1-polysilicon-1 0 7.35fF
C54 net@6891#3contact@2626_metal-1-polysilicon-1 0 7.135fF
C55 D8#0contact@2704_metal-1-metal-2 0 7.822fF
C56 net@6958#3contact@2657_metal-1-polysilicon-1 0 20.552fF
C57 net@6913#1contact@2639_metal-1-polysilicon-1 0 11.324fF
C58 net@6902 0 7.359fF
C59 D9#3contact@2629_metal-1-polysilicon-1 0 6.04fF
C60 S0#39contact@2641_metal-1-polysilicon-1 0 4.472fF
C61 net@6938 0 7.41fF
C62 D10#3contact@2645_metal-1-polysilicon-1 0 4.205fF
C63 net@6931 0 9.128fF
C64 net@7018#3contact@2674_metal-1-polysilicon-1 0 7.408fF
C65 D11 0 4.606fF
C66 net@7002#4contact@2666_metal-1-n-act 0 10.686fF
C67 net@6913#3contact@2676_metal-1-p-act 0 8.786fF
C68 D10 0 4.079fF
C69 D9 0 5.874fF
C70 D8 0 7.684fF
C71 net@7207 0 7.637fF
C72 net@7292#3contact@2713_metal-1-polysilicon-1 0 5.15fF
C73 net@7266 0 16.563fF
C74 net@7194 0 10.126fF
C75 net@7230#5contact@2727_metal-1-polysilicon-1 0 5.094fF
C76 net@7301#1contact@2728_metal-1-polysilicon-1 0 7.35fF
C77 net@7190#3contact@2744_metal-1-polysilicon-1 0 7.135fF
C78 D12#0contact@2822_metal-1-metal-2 0 7.822fF
C79 net@7257#3contact@2775_metal-1-polysilicon-1 0 20.552fF
C80 net@7212#1contact@2757_metal-1-polysilicon-1 0 11.324fF
C81 net@7201 0 7.359fF
C82 D13#3contact@2747_metal-1-polysilicon-1 0 6.04fF
C83 S0#57contact@2759_metal-1-polysilicon-1 0 4.472fF
C84 net@7237 0 7.41fF
C85 D14#3contact@2763_metal-1-polysilicon-1 0 4.205fF
C86 net@7230 0 9.128fF
C87 net@7317#3contact@2792_metal-1-polysilicon-1 0 7.408fF
C88 D15 0 4.606fF
C89 net@7301#4contact@2784_metal-1-n-act 0 10.686fF
C90 net@7212#3contact@2794_metal-1-p-act 0 8.786fF
C91 D14 0 4.079fF
C92 D13 0 5.874fF
C93 D12 0 7.684fF
C94 net@7506 0 7.637fF
C95 net@7591#3contact@2831_metal-1-polysilicon-1 0 5.15fF
C96 Vout 0 5.049fF
C97 net@7493 0 10.126fF
C98 net@7529#5contact@2845_metal-1-polysilicon-1 0 5.094fF
C99 net@7600#1contact@2846_metal-1-polysilicon-1 0 7.35fF
C100 net@7489#3contact@2862_metal-1-polysilicon-1 0 7.135fF
C101 net@6369#4contact@2940_metal-1-metal-2 0 6.996fF
C102 net@7556#3contact@2893_metal-1-polysilicon-1 0 20.552fF
C103 net@7511#1contact@2875_metal-1-polysilicon-1 0 11.324fF
C104 net@7500 0 7.359fF
C105 net@6668#7contact@2865_metal-1-polysilicon-1 0 5.214fF
C106 S2#3contact@2877_metal-1-polysilicon-1 0 4.472fF
C107 net@7536 0 7.41fF
C108 net@7529 0 9.128fF
C109 S3#1contact@2891_metal-1-polysilicon-1 0 19.947fF
C110 net@7616#3contact@2910_metal-1-polysilicon-1 0 7.408fF
C111 net@7600#4contact@2902_metal-1-n-act 0 10.686fF
C112 S2#8contact@2909_metal-1-polysilicon-1 0 14.839fF
C113 net@7511#3contact@2912_metal-1-p-act 0 8.786fF
C114 S2 0 9.494fF
C115 S3 0 9.585fF
C116 net@6310#12pin@1316_polysilicon-1 0 0.233fF
C117 net@6395#1pin@1318_polysilicon-1 0 0.217fF
C118 D0#4pin@1322_polysilicon-1 0 0.215fF
C119 net@6315#14pin@1328_polysilicon-1 0 0.208fF
C120 net@6293#1pin@1329_polysilicon-1 0 0.199fF
C121 D1#1pin@1330_polysilicon-1 0 0.24fF
C122 S0#1pin@1336_polysilicon-1 0 0.193fF
C123 net@6304#11pin@1337_polysilicon-1 0 0.192fF
C124 D2#1pin@1338_polysilicon-1 0 0.245fF
C125 net@6360#1pin@1344_polysilicon-1 0 0.208fF
C126 net@6340#11pin@1345_polysilicon-1 0 0.192fF
C127 S0#6pin@1351_polysilicon-1 0 0.198fF
C128 net@6420#1pin@1352_polysilicon-1 0 0.199fF
C129 S0#11pin@1353_polysilicon-1 0 0.244fF
C130 S1#12pin@1354_polysilicon-1 0 0.168fF
C131 D3#4pin@1355_polysilicon-1 0 0.244fF
C132 net@6609#12pin@1381_polysilicon-1 0 0.233fF
C133 net@6694#1pin@1383_polysilicon-1 0 0.217fF
C134 D4#4pin@1387_polysilicon-1 0 0.215fF
C135 net@6614#14pin@1393_polysilicon-1 0 0.208fF
C136 net@6592#1pin@1394_polysilicon-1 0 0.199fF
C137 D5#1pin@1395_polysilicon-1 0 0.24fF
C138 S0#19pin@1401_polysilicon-1 0 0.193fF
C139 net@6603#11pin@1402_polysilicon-1 0 0.192fF
C140 D6#1pin@1403_polysilicon-1 0 0.245fF
C141 net@6659#1pin@1409_polysilicon-1 0 0.208fF
C142 net@6639#11pin@1410_polysilicon-1 0 0.192fF
C143 S0#24pin@1416_polysilicon-1 0 0.198fF
C144 net@6719#1pin@1417_polysilicon-1 0 0.199fF
C145 S0#29pin@1418_polysilicon-1 0 0.242fF
C146 S1#29pin@1419_polysilicon-1 0 0.168fF
C147 D7#4pin@1420_polysilicon-1 0 0.244fF
C148 net@6908#12pin@1446_polysilicon-1 0 0.233fF
C149 net@6993#1pin@1448_polysilicon-1 0 0.217fF
C150 D8#4pin@1452_polysilicon-1 0 0.215fF
C151 net@6913#14pin@1458_polysilicon-1 0 0.208fF
C152 net@6891#1pin@1459_polysilicon-1 0 0.199fF
C153 D9#1pin@1460_polysilicon-1 0 0.24fF
C154 S0#37pin@1466_polysilicon-1 0 0.193fF
C155 net@6902#11pin@1467_polysilicon-1 0 0.192fF
C156 D10#1pin@1468_polysilicon-1 0 0.245fF
C157 net@6958#1pin@1474_polysilicon-1 0 0.208fF
C158 net@6938#11pin@1475_polysilicon-1 0 0.192fF
C159 S0#42pin@1481_polysilicon-1 0 0.198fF
C160 net@7018#1pin@1482_polysilicon-1 0 0.199fF
C161 S0#47pin@1483_polysilicon-1 0 0.244fF
C162 S1#46pin@1484_polysilicon-1 0 0.168fF
C163 D11#4pin@1485_polysilicon-1 0 0.244fF
C164 net@7207#12pin@1511_polysilicon-1 0 0.233fF
C165 net@7292#1pin@1513_polysilicon-1 0 0.217fF
C166 D12#4pin@1517_polysilicon-1 0 0.215fF
C167 net@7212#14pin@1523_polysilicon-1 0 0.208fF
C168 net@7190#1pin@1524_polysilicon-1 0 0.199fF
C169 D13#1pin@1525_polysilicon-1 0 0.24fF
C170 S0#55pin@1531_polysilicon-1 0 0.193fF
C171 net@7201#11pin@1532_polysilicon-1 0 0.192fF
C172 D14#1pin@1533_polysilicon-1 0 0.245fF
C173 net@7257#1pin@1539_polysilicon-1 0 0.208fF
C174 net@7237#11pin@1540_polysilicon-1 0 0.192fF
C175 S0#60pin@1546_polysilicon-1 0 0.198fF
C176 net@7317#1pin@1547_polysilicon-1 0 0.199fF
C177 S0#65pin@1548_polysilicon-1 0 0.245fF
C178 S1#63pin@1549_polysilicon-1 0 0.168fF
C179 D15#4pin@1550_polysilicon-1 0 0.244fF
C180 net@7506#12pin@1576_polysilicon-1 0 0.233fF
C181 net@7591#1pin@1578_polysilicon-1 0 0.217fF
C182 net@6369#8pin@1582_polysilicon-1 0 0.215fF
C183 net@7511#14pin@1588_polysilicon-1 0 0.208fF
C184 net@7489#1pin@1589_polysilicon-1 0 0.199fF
C185 net@6668#5pin@1590_polysilicon-1 0 0.24fF
C186 S2#1pin@1596_polysilicon-1 0 0.193fF
C187 net@7500#11pin@1597_polysilicon-1 0 0.192fF
C188 net@6967#5pin@1598_polysilicon-1 0 0.245fF
C189 net@7556#1pin@1604_polysilicon-1 0 0.208fF
C190 net@7536#11pin@1605_polysilicon-1 0 0.192fF
C191 S2#6pin@1611_polysilicon-1 0 0.198fF
C192 net@7616#1pin@1612_polysilicon-1 0 0.199fF
C193 S2#11pin@1613_polysilicon-1 0 0.24fF
C194 S3#13pin@1614_polysilicon-1 0 0.168fF
C195 net@7266#8pin@1615_polysilicon-1 0 0.244fF
C196 S2#18pin@1654_metal-1 0 14.593fF
C197 S3#19pin@1656_metal-1 0 13.714fF
** Extracted Parasitic Resistors ***
R0 net@6293 net@6293#1pin@1329_polysilicon-1 7.75
R1 net@6293#1pin@1329_polysilicon-1 net@6293#1pin@1329_polysilicon-1##0 9.623
R2 net@6293#1pin@1329_polysilicon-1##0 net@6293#1pin@1329_polysilicon-1##1 9.623
R3 net@6293#1pin@1329_polysilicon-1##1 net@6293#1pin@1329_polysilicon-1##2 9.623
R4 net@6293#1pin@1329_polysilicon-1##2 net@6293#1pin@1329_polysilicon-1##3 9.623
R5 net@6293#1pin@1329_polysilicon-1##3 net@6293#1pin@1329_polysilicon-1##4 9.623
R6 net@6293#1pin@1329_polysilicon-1##4 net@6293#1pin@1329_polysilicon-1##5 9.623
R7 net@6293#1pin@1329_polysilicon-1##5 net@6293#1pin@1329_polysilicon-1##6 9.623
R8 net@6293#1pin@1329_polysilicon-1##6 net@6293#1pin@1329_polysilicon-1##7 9.623
R9 net@6293#1pin@1329_polysilicon-1##7 net@6293#1pin@1329_polysilicon-1##8 9.623
R10 net@6293#1pin@1329_polysilicon-1##8 net@6293#1pin@1329_polysilicon-1##9 9.623
R11 net@6293#1pin@1329_polysilicon-1##9 net@6293#1pin@1329_polysilicon-1##10 9.623
R12 net@6293#1pin@1329_polysilicon-1##10 net@6293#1pin@1329_polysilicon-1##11 9.623
R13 net@6293#1pin@1329_polysilicon-1##11 net@6293#1pin@1329_polysilicon-1##12 9.623
R14 net@6293#1pin@1329_polysilicon-1##12 net@6293#1pin@1329_polysilicon-1##13 9.623
R15 net@6293#1pin@1329_polysilicon-1##13 net@6293#1pin@1329_polysilicon-1##14 9.623
R16 net@6293#1pin@1329_polysilicon-1##14 net@6293#1pin@1329_polysilicon-1##15 9.623
R17 net@6293#1pin@1329_polysilicon-1##15 net@6293#1pin@1329_polysilicon-1##16 9.623
R18 net@6293#1pin@1329_polysilicon-1##16 net@6293#1pin@1329_polysilicon-1##17 9.623
R19 net@6293#1pin@1329_polysilicon-1##17 net@6293#1pin@1329_polysilicon-1##18 9.623
R20 net@6293#1pin@1329_polysilicon-1##18 net@6293#1pin@1329_polysilicon-1##19 9.623
R21 net@6293#1pin@1329_polysilicon-1##19 net@6293#1pin@1329_polysilicon-1##20 9.623
R22 net@6293#1pin@1329_polysilicon-1##20 net@6293#1pin@1329_polysilicon-1##21 9.623
R23 net@6293#1pin@1329_polysilicon-1##21 net@6293#1pin@1329_polysilicon-1##22 9.623
R24 net@6293#1pin@1329_polysilicon-1##22 net@6293#2nmos@467_poly-right 9.623
R25 net@6293#3contact@2390_metal-1-polysilicon-1 net@6293#3contact@2390_metal-1-polysilicon-1##0 8.68
R26 net@6293#3contact@2390_metal-1-polysilicon-1##0 net@6293#3contact@2390_metal-1-polysilicon-1##1 8.68
R27 net@6293#3contact@2390_metal-1-polysilicon-1##1 net@6293#3contact@2390_metal-1-polysilicon-1##2 8.68
R28 net@6293#3contact@2390_metal-1-polysilicon-1##2 net@6293#3contact@2390_metal-1-polysilicon-1##3 8.68
R29 net@6293#3contact@2390_metal-1-polysilicon-1##3 net@6293#1pin@1329_polysilicon-1 8.68
R30 net@6297 net@6297 0
R31 D1#0nmos@469_poly-left D1#0nmos@469_poly-left##0 9.953
R32 D1#0nmos@469_poly-left##0 D1#0nmos@469_poly-left##1 9.953
R33 D1#0nmos@469_poly-left##1 D1#0nmos@469_poly-left##2 9.953
R34 D1#0nmos@469_poly-left##2 D1#0nmos@469_poly-left##3 9.953
R35 D1#0nmos@469_poly-left##3 D1#0nmos@469_poly-left##4 9.953
R36 D1#0nmos@469_poly-left##4 D1#0nmos@469_poly-left##5 9.953
R37 D1#0nmos@469_poly-left##5 D1#0nmos@469_poly-left##6 9.953
R38 D1#0nmos@469_poly-left##6 D1#0nmos@469_poly-left##7 9.953
R39 D1#0nmos@469_poly-left##7 D1#0nmos@469_poly-left##8 9.953
R40 D1#0nmos@469_poly-left##8 D1#0nmos@469_poly-left##9 9.953
R41 D1#0nmos@469_poly-left##9 D1#0nmos@469_poly-left##10 9.953
R42 D1#0nmos@469_poly-left##10 D1#0nmos@469_poly-left##11 9.953
R43 D1#0nmos@469_poly-left##11 D1#0nmos@469_poly-left##12 9.953
R44 D1#0nmos@469_poly-left##12 D1#0nmos@469_poly-left##13 9.953
R45 D1#0nmos@469_poly-left##13 D1#0nmos@469_poly-left##14 9.953
R46 D1#0nmos@469_poly-left##14 D1#0nmos@469_poly-left##15 9.953
R47 D1#0nmos@469_poly-left##15 D1#0nmos@469_poly-left##16 9.953
R48 D1#0nmos@469_poly-left##16 D1#0nmos@469_poly-left##17 9.953
R49 D1#0nmos@469_poly-left##17 D1#1pin@1330_polysilicon-1 9.953
R50 D1#1pin@1330_polysilicon-1 D1#1pin@1330_polysilicon-1##0 9.92
R51 D1#1pin@1330_polysilicon-1##0 D1#1pin@1330_polysilicon-1##1 9.92
R52 D1#1pin@1330_polysilicon-1##1 D1#1pin@1330_polysilicon-1##2 9.92
R53 D1#1pin@1330_polysilicon-1##2 D1#1pin@1330_polysilicon-1##3 9.92
R54 D1#1pin@1330_polysilicon-1##3 D1#2pmos@470_poly-right 9.92
R55 D1#3contact@2393_metal-1-polysilicon-1 D1#3contact@2393_metal-1-polysilicon-1##0 8.525
R56 D1#3contact@2393_metal-1-polysilicon-1##0 D1#3contact@2393_metal-1-polysilicon-1##1 8.525
R57 D1#3contact@2393_metal-1-polysilicon-1##1 D1#3contact@2393_metal-1-polysilicon-1##2 8.525
R58 D1#3contact@2393_metal-1-polysilicon-1##2 D1#1pin@1330_polysilicon-1 8.525
R59 net@6315 net@6315##0 9.545
R60 net@6315##0 net@6315##1 9.545
R61 net@6315##1 net@6315##2 9.545
R62 net@6315##2 net@6315##3 9.545
R63 net@6315##3 net@6315##4 9.545
R64 net@6315##4 net@6315##5 9.545
R65 net@6315##5 net@6315##6 9.545
R66 net@6315##6 net@6315##7 9.545
R67 net@6315##7 net@6315##8 9.545
R68 net@6315##8 net@6315##9 9.545
R69 net@6315##9 net@6315##10 9.545
R70 net@6315##10 net@6315##11 9.545
R71 net@6315##11 net@6315##12 9.545
R72 net@6315##12 net@6315##13 9.545
R73 net@6315##13 net@6315##14 9.545
R74 net@6315##14 net@6315##15 9.545
R75 net@6315##15 net@6315##16 9.545
R76 net@6315##16 net@6315##17 9.545
R77 net@6315##17 net@6315#1contact@2403_metal-1-polysilicon-1 9.545
R78 net@6315#1contact@2403_metal-1-polysilicon-1 net@6315#1contact@2403_metal-1-polysilicon-1##0 9.558
R79 net@6315#1contact@2403_metal-1-polysilicon-1##0 net@6315#1contact@2403_metal-1-polysilicon-1##1 9.558
R80 net@6315#1contact@2403_metal-1-polysilicon-1##1 net@6315#1contact@2403_metal-1-polysilicon-1##2 9.558
R81 net@6315#1contact@2403_metal-1-polysilicon-1##2 net@6315#1contact@2403_metal-1-polysilicon-1##3 9.558
R82 net@6315#1contact@2403_metal-1-polysilicon-1##3 net@6315#1contact@2403_metal-1-polysilicon-1##4 9.558
R83 net@6315#1contact@2403_metal-1-polysilicon-1##4 net@6315#2nmos@470_poly-left 9.558
R84 S0#0pmos@472_poly-right S0#0pmos@472_poly-right##0 9.743
R85 S0#0pmos@472_poly-right##0 S0#0pmos@472_poly-right##1 9.743
R86 S0#0pmos@472_poly-right##1 S0#0pmos@472_poly-right##2 9.743
R87 S0#0pmos@472_poly-right##2 S0#0pmos@472_poly-right##3 9.743
R88 S0#0pmos@472_poly-right##3 S0#0pmos@472_poly-right##4 9.743
R89 S0#0pmos@472_poly-right##4 S0#0pmos@472_poly-right##5 9.743
R90 S0#0pmos@472_poly-right##5 S0#0pmos@472_poly-right##6 9.743
R91 S0#0pmos@472_poly-right##6 S0#0pmos@472_poly-right##7 9.743
R92 S0#0pmos@472_poly-right##7 S0#0pmos@472_poly-right##8 9.743
R93 S0#0pmos@472_poly-right##8 S0#0pmos@472_poly-right##9 9.743
R94 S0#0pmos@472_poly-right##9 S0#0pmos@472_poly-right##10 9.743
R95 S0#0pmos@472_poly-right##10 S0#0pmos@472_poly-right##11 9.743
R96 S0#0pmos@472_poly-right##11 S0#0pmos@472_poly-right##12 9.743
R97 S0#0pmos@472_poly-right##12 S0#0pmos@472_poly-right##13 9.743
R98 S0#0pmos@472_poly-right##13 S0#0pmos@472_poly-right##14 9.743
R99 S0#0pmos@472_poly-right##14 S0#0pmos@472_poly-right##15 9.743
R100 S0#0pmos@472_poly-right##15 S0#0pmos@472_poly-right##16 9.743
R101 S0#0pmos@472_poly-right##16 S0#0pmos@472_poly-right##17 9.743
R102 S0#0pmos@472_poly-right##17 S0#0pmos@472_poly-right##18 9.743
R103 S0#0pmos@472_poly-right##18 S0#0pmos@472_poly-right##19 9.743
R104 S0#0pmos@472_poly-right##19 S0#1pin@1336_polysilicon-1 9.743
R105 S0#1pin@1336_polysilicon-1 S0#1pin@1336_polysilicon-1##0 8.525
R106 S0#1pin@1336_polysilicon-1##0 S0#1pin@1336_polysilicon-1##1 8.525
R107 S0#1pin@1336_polysilicon-1##1 S0#1pin@1336_polysilicon-1##2 8.525
R108 S0#1pin@1336_polysilicon-1##2 S0#2nmos@472_poly-left 8.525
R109 S0#3contact@2405_metal-1-polysilicon-1 S0#3contact@2405_metal-1-polysilicon-1##0 5.425
R110 S0#3contact@2405_metal-1-polysilicon-1##0 S0#1pin@1336_polysilicon-1 5.425
R111 net@6304#10pmos@471_poly-right net@6304#11pin@1337_polysilicon-1 6.2
R112 net@6304#11pin@1337_polysilicon-1 net@6304#11pin@1337_polysilicon-1##0 9.688
R113 net@6304#11pin@1337_polysilicon-1##0 net@6304#11pin@1337_polysilicon-1##1 9.688
R114 net@6304#11pin@1337_polysilicon-1##1 net@6304#11pin@1337_polysilicon-1##2 9.688
R115 net@6304#11pin@1337_polysilicon-1##2 net@6304#11pin@1337_polysilicon-1##3 9.688
R116 net@6304#11pin@1337_polysilicon-1##3 net@6304#11pin@1337_polysilicon-1##4 9.688
R117 net@6304#11pin@1337_polysilicon-1##4 net@6304#11pin@1337_polysilicon-1##5 9.688
R118 net@6304#11pin@1337_polysilicon-1##5 net@6304#11pin@1337_polysilicon-1##6 9.688
R119 net@6304#11pin@1337_polysilicon-1##6 net@6304#11pin@1337_polysilicon-1##7 9.688
R120 net@6304#11pin@1337_polysilicon-1##7 net@6304#11pin@1337_polysilicon-1##8 9.688
R121 net@6304#11pin@1337_polysilicon-1##8 net@6304#11pin@1337_polysilicon-1##9 9.688
R122 net@6304#11pin@1337_polysilicon-1##9 net@6304#11pin@1337_polysilicon-1##10 9.688
R123 net@6304#11pin@1337_polysilicon-1##10 net@6304#11pin@1337_polysilicon-1##11 9.688
R124 net@6304#11pin@1337_polysilicon-1##11 net@6304#11pin@1337_polysilicon-1##12 9.688
R125 net@6304#11pin@1337_polysilicon-1##12 net@6304#11pin@1337_polysilicon-1##13 9.688
R126 net@6304#11pin@1337_polysilicon-1##13 net@6304#11pin@1337_polysilicon-1##14 9.688
R127 net@6304#11pin@1337_polysilicon-1##14 net@6304#11pin@1337_polysilicon-1##15 9.688
R128 net@6304#11pin@1337_polysilicon-1##15 net@6304#11pin@1337_polysilicon-1##16 9.688
R129 net@6304#11pin@1337_polysilicon-1##16 net@6304#11pin@1337_polysilicon-1##17 9.688
R130 net@6304#11pin@1337_polysilicon-1##17 net@6304#11pin@1337_polysilicon-1##18 9.688
R131 net@6304#11pin@1337_polysilicon-1##18 net@6304#11pin@1337_polysilicon-1##19 9.688
R132 net@6304#11pin@1337_polysilicon-1##19 net@6304#11pin@1337_polysilicon-1##20 9.688
R133 net@6304#11pin@1337_polysilicon-1##20 net@6304#11pin@1337_polysilicon-1##21 9.688
R134 net@6304#11pin@1337_polysilicon-1##21 net@6304#11pin@1337_polysilicon-1##22 9.688
R135 net@6304#11pin@1337_polysilicon-1##22 net@6304#12nmos@471_poly-right 9.688
R136 net@6304 net@6304##0 8.68
R137 net@6304##0 net@6304##1 8.68
R138 net@6304##1 net@6304##2 8.68
R139 net@6304##2 net@6304##3 8.68
R140 net@6304##3 net@6304#11pin@1337_polysilicon-1 8.68
R141 net@6333 net@6333 0
R142 D2#0nmos@473_poly-left D2#0nmos@473_poly-left##0 9.665
R143 D2#0nmos@473_poly-left##0 D2#0nmos@473_poly-left##1 9.665
R144 D2#0nmos@473_poly-left##1 D2#0nmos@473_poly-left##2 9.665
R145 D2#0nmos@473_poly-left##2 D2#0nmos@473_poly-left##3 9.665
R146 D2#0nmos@473_poly-left##3 D2#0nmos@473_poly-left##4 9.665
R147 D2#0nmos@473_poly-left##4 D2#0nmos@473_poly-left##5 9.665
R148 D2#0nmos@473_poly-left##5 D2#0nmos@473_poly-left##6 9.665
R149 D2#0nmos@473_poly-left##6 D2#0nmos@473_poly-left##7 9.665
R150 D2#0nmos@473_poly-left##7 D2#0nmos@473_poly-left##8 9.665
R151 D2#0nmos@473_poly-left##8 D2#0nmos@473_poly-left##9 9.665
R152 D2#0nmos@473_poly-left##9 D2#0nmos@473_poly-left##10 9.665
R153 D2#0nmos@473_poly-left##10 D2#0nmos@473_poly-left##11 9.665
R154 D2#0nmos@473_poly-left##11 D2#0nmos@473_poly-left##12 9.665
R155 D2#0nmos@473_poly-left##12 D2#0nmos@473_poly-left##13 9.665
R156 D2#0nmos@473_poly-left##13 D2#0nmos@473_poly-left##14 9.665
R157 D2#0nmos@473_poly-left##14 D2#0nmos@473_poly-left##15 9.665
R158 D2#0nmos@473_poly-left##15 D2#1pin@1338_polysilicon-1 9.665
R159 D2#1pin@1338_polysilicon-1 D2#1pin@1338_polysilicon-1##0 9.3
R160 D2#1pin@1338_polysilicon-1##0 D2#1pin@1338_polysilicon-1##1 9.3
R161 D2#1pin@1338_polysilicon-1##1 D2#1pin@1338_polysilicon-1##2 9.3
R162 D2#1pin@1338_polysilicon-1##2 D2#1pin@1338_polysilicon-1##3 9.3
R163 D2#1pin@1338_polysilicon-1##3 D2#1pin@1338_polysilicon-1##4 9.3
R164 D2#1pin@1338_polysilicon-1##4 D2#1pin@1338_polysilicon-1##5 9.3
R165 D2#1pin@1338_polysilicon-1##5 D2#1pin@1338_polysilicon-1##6 9.3
R166 D2#1pin@1338_polysilicon-1##6 D2#2pmos@474_poly-right 9.3
R167 D2#3contact@2409_metal-1-polysilicon-1 D2#3contact@2409_metal-1-polysilicon-1##0 9.688
R168 D2#3contact@2409_metal-1-polysilicon-1##0 D2#3contact@2409_metal-1-polysilicon-1##1 9.688
R169 D2#3contact@2409_metal-1-polysilicon-1##1 D2#3contact@2409_metal-1-polysilicon-1##2 9.688
R170 D2#3contact@2409_metal-1-polysilicon-1##2 D2#1pin@1338_polysilicon-1 9.688
R171 S1#0pmos@473_poly-right S1#0pmos@473_poly-right##0 9.3
R172 S1#0pmos@473_poly-right##0 S1#0pmos@473_poly-right##1 9.3
R173 S1#0pmos@473_poly-right##1 S1#0pmos@473_poly-right##2 9.3
R174 S1#0pmos@473_poly-right##2 S1#0pmos@473_poly-right##3 9.3
R175 S1#0pmos@473_poly-right##3 S1#0pmos@473_poly-right##4 9.3
R176 S1#0pmos@473_poly-right##4 S1#0pmos@473_poly-right##5 9.3
R177 S1#0pmos@473_poly-right##5 S1#0pmos@473_poly-right##6 9.3
R178 S1#0pmos@473_poly-right##6 S1#0pmos@473_poly-right##7 9.3
R179 S1#0pmos@473_poly-right##7 S1#0pmos@473_poly-right##8 9.3
R180 S1#0pmos@473_poly-right##8 S1 9.3
R181 S1 S1##0 9.713
R182 S1##0 S1##1 9.713
R183 S1##1 S1##2 9.713
R184 S1##2 S1##3 9.713
R185 S1##3 S1##4 9.713
R186 S1##4 S1##5 9.713
R187 S1##5 S1##6 9.713
R188 S1##6 S1##7 9.713
R189 S1##7 S1##8 9.713
R190 S1##8 S1##9 9.713
R191 S1##9 S1##10 9.713
R192 S1##10 S1##11 9.713
R193 S1##11 S1##12 9.713
R194 S1##12 S1##13 9.713
R195 S1##13 S1#2nmos@474_poly-left 9.713
R196 net@6360 net@6360##0 9.817
R197 net@6360##0 net@6360##1 9.817
R198 net@6360##1 net@6360##2 9.817
R199 net@6360##2 net@6360##3 9.817
R200 net@6360##3 net@6360##4 9.817
R201 net@6360##4 net@6360##5 9.817
R202 net@6360##5 net@6360##6 9.817
R203 net@6360##6 net@6360##7 9.817
R204 net@6360##7 net@6360##8 9.817
R205 net@6360##8 net@6360##9 9.817
R206 net@6360##9 net@6360##10 9.817
R207 net@6360##10 net@6360#1pin@1344_polysilicon-1 9.817
R208 net@6360#1pin@1344_polysilicon-1 net@6360#1pin@1344_polysilicon-1##0 9.3
R209 net@6360#1pin@1344_polysilicon-1##0 net@6360#1pin@1344_polysilicon-1##1 9.3
R210 net@6360#1pin@1344_polysilicon-1##1 net@6360#1pin@1344_polysilicon-1##2 9.3
R211 net@6360#1pin@1344_polysilicon-1##2 net@6360#1pin@1344_polysilicon-1##3 9.3
R212 net@6360#1pin@1344_polysilicon-1##3 net@6360#1pin@1344_polysilicon-1##4 9.3
R213 net@6360#1pin@1344_polysilicon-1##4 net@6360#1pin@1344_polysilicon-1##5 9.3
R214 net@6360#1pin@1344_polysilicon-1##5 net@6360#1pin@1344_polysilicon-1##6 9.3
R215 net@6360#1pin@1344_polysilicon-1##6 net@6360#1pin@1344_polysilicon-1##7 9.3
R216 net@6360#1pin@1344_polysilicon-1##7 net@6360#1pin@1344_polysilicon-1##8 9.3
R217 net@6360#1pin@1344_polysilicon-1##8 net@6360#1pin@1344_polysilicon-1##9 9.3
R218 net@6360#1pin@1344_polysilicon-1##9 net@6360#1pin@1344_polysilicon-1##10 9.3
R219 net@6360#1pin@1344_polysilicon-1##10 net@6360#1pin@1344_polysilicon-1##11 9.3
R220 net@6360#1pin@1344_polysilicon-1##11 net@6360#2nmos@476_poly-left 9.3
R221 net@6360#3contact@2421_metal-1-polysilicon-1 net@6360#3contact@2421_metal-1-polysilicon-1##0 5.425
R222 net@6360#3contact@2421_metal-1-polysilicon-1##0 net@6360#1pin@1344_polysilicon-1 5.425
R223 net@6340#10pmos@475_poly-right net@6340#11pin@1345_polysilicon-1 6.2
R224 net@6340#11pin@1345_polysilicon-1 net@6340#11pin@1345_polysilicon-1##0 9.688
R225 net@6340#11pin@1345_polysilicon-1##0 net@6340#11pin@1345_polysilicon-1##1 9.688
R226 net@6340#11pin@1345_polysilicon-1##1 net@6340#11pin@1345_polysilicon-1##2 9.688
R227 net@6340#11pin@1345_polysilicon-1##2 net@6340#11pin@1345_polysilicon-1##3 9.688
R228 net@6340#11pin@1345_polysilicon-1##3 net@6340#11pin@1345_polysilicon-1##4 9.688
R229 net@6340#11pin@1345_polysilicon-1##4 net@6340#11pin@1345_polysilicon-1##5 9.688
R230 net@6340#11pin@1345_polysilicon-1##5 net@6340#11pin@1345_polysilicon-1##6 9.688
R231 net@6340#11pin@1345_polysilicon-1##6 net@6340#11pin@1345_polysilicon-1##7 9.688
R232 net@6340#11pin@1345_polysilicon-1##7 net@6340#11pin@1345_polysilicon-1##8 9.688
R233 net@6340#11pin@1345_polysilicon-1##8 net@6340#11pin@1345_polysilicon-1##9 9.688
R234 net@6340#11pin@1345_polysilicon-1##9 net@6340#11pin@1345_polysilicon-1##10 9.688
R235 net@6340#11pin@1345_polysilicon-1##10 net@6340#11pin@1345_polysilicon-1##11 9.688
R236 net@6340#11pin@1345_polysilicon-1##11 net@6340#11pin@1345_polysilicon-1##12 9.688
R237 net@6340#11pin@1345_polysilicon-1##12 net@6340#11pin@1345_polysilicon-1##13 9.688
R238 net@6340#11pin@1345_polysilicon-1##13 net@6340#11pin@1345_polysilicon-1##14 9.688
R239 net@6340#11pin@1345_polysilicon-1##14 net@6340#11pin@1345_polysilicon-1##15 9.688
R240 net@6340#11pin@1345_polysilicon-1##15 net@6340#11pin@1345_polysilicon-1##16 9.688
R241 net@6340#11pin@1345_polysilicon-1##16 net@6340#11pin@1345_polysilicon-1##17 9.688
R242 net@6340#11pin@1345_polysilicon-1##17 net@6340#11pin@1345_polysilicon-1##18 9.688
R243 net@6340#11pin@1345_polysilicon-1##18 net@6340#11pin@1345_polysilicon-1##19 9.688
R244 net@6340#11pin@1345_polysilicon-1##19 net@6340#11pin@1345_polysilicon-1##20 9.688
R245 net@6340#11pin@1345_polysilicon-1##20 net@6340#11pin@1345_polysilicon-1##21 9.688
R246 net@6340#11pin@1345_polysilicon-1##21 net@6340#11pin@1345_polysilicon-1##22 9.688
R247 net@6340#11pin@1345_polysilicon-1##22 net@6340#12nmos@475_poly-right 9.688
R248 net@6340 net@6340##0 8.68
R249 net@6340##0 net@6340##1 8.68
R250 net@6340##1 net@6340##2 8.68
R251 net@6340##2 net@6340##3 8.68
R252 net@6340##3 net@6340#11pin@1345_polysilicon-1 8.68
R253 net@6369 net@6369 0
R254 net@6310#11pmos@461_poly-right net@6310#11pmos@461_poly-right##0 9.743
R255 net@6310#11pmos@461_poly-right##0 net@6310#11pmos@461_poly-right##1 9.743
R256 net@6310#11pmos@461_poly-right##1 net@6310#11pmos@461_poly-right##2 9.743
R257 net@6310#11pmos@461_poly-right##2 net@6310#11pmos@461_poly-right##3 9.743
R258 net@6310#11pmos@461_poly-right##3 net@6310#11pmos@461_poly-right##4 9.743
R259 net@6310#11pmos@461_poly-right##4 net@6310#11pmos@461_poly-right##5 9.743
R260 net@6310#11pmos@461_poly-right##5 net@6310#11pmos@461_poly-right##6 9.743
R261 net@6310#11pmos@461_poly-right##6 net@6310#11pmos@461_poly-right##7 9.743
R262 net@6310#11pmos@461_poly-right##7 net@6310#11pmos@461_poly-right##8 9.743
R263 net@6310#11pmos@461_poly-right##8 net@6310#11pmos@461_poly-right##9 9.743
R264 net@6310#11pmos@461_poly-right##9 net@6310#11pmos@461_poly-right##10 9.743
R265 net@6310#11pmos@461_poly-right##10 net@6310#11pmos@461_poly-right##11 9.743
R266 net@6310#11pmos@461_poly-right##11 net@6310#11pmos@461_poly-right##12 9.743
R267 net@6310#11pmos@461_poly-right##12 net@6310#11pmos@461_poly-right##13 9.743
R268 net@6310#11pmos@461_poly-right##13 net@6310#11pmos@461_poly-right##14 9.743
R269 net@6310#11pmos@461_poly-right##14 net@6310#11pmos@461_poly-right##15 9.743
R270 net@6310#11pmos@461_poly-right##15 net@6310#11pmos@461_poly-right##16 9.743
R271 net@6310#11pmos@461_poly-right##16 net@6310#11pmos@461_poly-right##17 9.743
R272 net@6310#11pmos@461_poly-right##17 net@6310#11pmos@461_poly-right##18 9.743
R273 net@6310#11pmos@461_poly-right##18 net@6310#11pmos@461_poly-right##19 9.743
R274 net@6310#11pmos@461_poly-right##19 net@6310#12pin@1316_polysilicon-1 9.743
R275 net@6310#12pin@1316_polysilicon-1 net@6310#12pin@1316_polysilicon-1##0 8.525
R276 net@6310#12pin@1316_polysilicon-1##0 net@6310#12pin@1316_polysilicon-1##1 8.525
R277 net@6310#12pin@1316_polysilicon-1##1 net@6310#12pin@1316_polysilicon-1##2 8.525
R278 net@6310#12pin@1316_polysilicon-1##2 net@6310#13nmos@462_poly-right 8.525
R279 net@6310 net@6310##0 9.042
R280 net@6310##0 net@6310##1 9.042
R281 net@6310##1 net@6310##2 9.042
R282 net@6310##2 net@6310##3 9.042
R283 net@6310##3 net@6310##4 9.042
R284 net@6310##4 net@6310#12pin@1316_polysilicon-1 9.042
R285 net@6395 net@6395##0 9.704
R286 net@6395##0 net@6395##1 9.704
R287 net@6395##1 net@6395##2 9.704
R288 net@6395##2 net@6395##3 9.704
R289 net@6395##3 net@6395##4 9.704
R290 net@6395##4 net@6395##5 9.704
R291 net@6395##5 net@6395##6 9.704
R292 net@6395##6 net@6395##7 9.704
R293 net@6395##7 net@6395##8 9.704
R294 net@6395##8 net@6395##9 9.704
R295 net@6395##9 net@6395##10 9.704
R296 net@6395##10 net@6395##11 9.704
R297 net@6395##11 net@6395##12 9.704
R298 net@6395##12 net@6395##13 9.704
R299 net@6395##13 net@6395##14 9.704
R300 net@6395##14 net@6395##15 9.704
R301 net@6395##15 net@6395##16 9.704
R302 net@6395##16 net@6395##17 9.704
R303 net@6395##17 net@6395##18 9.704
R304 net@6395##18 net@6395##19 9.704
R305 net@6395##19 net@6395##20 9.704
R306 net@6395##20 net@6395##21 9.704
R307 net@6395##21 net@6395#1pin@1318_polysilicon-1 9.704
R308 net@6395#1pin@1318_polysilicon-1 net@6395#1pin@1318_polysilicon-1##0 7.75
R309 net@6395#1pin@1318_polysilicon-1##0 net@6395#2pmos@462_poly-right 7.75
R310 net@6395#3contact@2359_metal-1-polysilicon-1 net@6395#3contact@2359_metal-1-polysilicon-1##0 9.3
R311 net@6395#3contact@2359_metal-1-polysilicon-1##0 net@6395#3contact@2359_metal-1-polysilicon-1##1 9.3
R312 net@6395#3contact@2359_metal-1-polysilicon-1##1 net@6395#3contact@2359_metal-1-polysilicon-1##2 9.3
R313 net@6395#3contact@2359_metal-1-polysilicon-1##2 net@6395#3contact@2359_metal-1-polysilicon-1##3 9.3
R314 net@6395#3contact@2359_metal-1-polysilicon-1##3 net@6395#1pin@1318_polysilicon-1 9.3
R315 net@6297#4pmos@460_poly-right net@6297#4pmos@460_poly-right##0 8.783
R316 net@6297#4pmos@460_poly-right##0 net@6297#4pmos@460_poly-right##1 8.783
R317 net@6297#4pmos@460_poly-right##1 net@6297#4pmos@460_poly-right##2 8.783
R318 net@6297#4pmos@460_poly-right##2 net@6297#4pmos@460_poly-right##3 8.783
R319 net@6297#4pmos@460_poly-right##3 net@6297#4pmos@460_poly-right##4 8.783
R320 net@6297#4pmos@460_poly-right##4 net@6297 8.783
R321 net@6297 net@6297##0 9.789
R322 net@6297##0 net@6297##1 9.789
R323 net@6297##1 net@6297##2 9.789
R324 net@6297##2 net@6297##3 9.789
R325 net@6297##3 net@6297##4 9.789
R326 net@6297##4 net@6297##5 9.789
R327 net@6297##5 net@6297##6 9.789
R328 net@6297##6 net@6297##7 9.789
R329 net@6297##7 net@6297##8 9.789
R330 net@6297##8 net@6297##9 9.789
R331 net@6297##9 net@6297##10 9.789
R332 net@6297##10 net@6297##11 9.789
R333 net@6297##11 net@6297##12 9.789
R334 net@6297##12 net@6297##13 9.789
R335 net@6297##13 net@6297##14 9.789
R336 net@6297##14 net@6297##15 9.789
R337 net@6297##15 net@6297##16 9.789
R338 net@6297##16 net@6297##17 9.789
R339 net@6297##17 net@6297#6nmos@461_poly-left 9.789
R340 net@6333#4nmos@463_poly-left net@6333#4nmos@463_poly-left##0 9.756
R341 net@6333#4nmos@463_poly-left##0 net@6333#4nmos@463_poly-left##1 9.756
R342 net@6333#4nmos@463_poly-left##1 net@6333#4nmos@463_poly-left##2 9.756
R343 net@6333#4nmos@463_poly-left##2 net@6333#4nmos@463_poly-left##3 9.756
R344 net@6333#4nmos@463_poly-left##3 net@6333#4nmos@463_poly-left##4 9.756
R345 net@6333#4nmos@463_poly-left##4 net@6333#4nmos@463_poly-left##5 9.756
R346 net@6333#4nmos@463_poly-left##5 net@6333#4nmos@463_poly-left##6 9.756
R347 net@6333#4nmos@463_poly-left##6 net@6333#4nmos@463_poly-left##7 9.756
R348 net@6333#4nmos@463_poly-left##7 net@6333#4nmos@463_poly-left##8 9.756
R349 net@6333#4nmos@463_poly-left##8 net@6333#4nmos@463_poly-left##9 9.756
R350 net@6333#4nmos@463_poly-left##9 net@6333#4nmos@463_poly-left##10 9.756
R351 net@6333#4nmos@463_poly-left##10 net@6333#4nmos@463_poly-left##11 9.756
R352 net@6333#4nmos@463_poly-left##11 net@6333#4nmos@463_poly-left##12 9.756
R353 net@6333#4nmos@463_poly-left##12 net@6333#4nmos@463_poly-left##13 9.756
R354 net@6333#4nmos@463_poly-left##13 net@6333#4nmos@463_poly-left##14 9.756
R355 net@6333#4nmos@463_poly-left##14 net@6333#4nmos@463_poly-left##15 9.756
R356 net@6333#4nmos@463_poly-left##15 net@6333#5contact@2373_metal-1-polysilicon-1 9.756
R357 net@6333#5contact@2373_metal-1-polysilicon-1 net@6333#5contact@2373_metal-1-polysilicon-1##0 9.106
R358 net@6333#5contact@2373_metal-1-polysilicon-1##0 net@6333#5contact@2373_metal-1-polysilicon-1##1 9.106
R359 net@6333#5contact@2373_metal-1-polysilicon-1##1 net@6333#5contact@2373_metal-1-polysilicon-1##2 9.106
R360 net@6333#5contact@2373_metal-1-polysilicon-1##2 net@6333#5contact@2373_metal-1-polysilicon-1##3 9.106
R361 net@6333#5contact@2373_metal-1-polysilicon-1##3 net@6333#5contact@2373_metal-1-polysilicon-1##4 9.106
R362 net@6333#5contact@2373_metal-1-polysilicon-1##4 net@6333#5contact@2373_metal-1-polysilicon-1##5 9.106
R363 net@6333#5contact@2373_metal-1-polysilicon-1##5 net@6333#5contact@2373_metal-1-polysilicon-1##6 9.106
R364 net@6333#5contact@2373_metal-1-polysilicon-1##6 net@6333#6pmos@464_poly-right 9.106
R365 net@6404 net@6404##0 9.574
R366 net@6404##0 net@6404##1 9.574
R367 net@6404##1 net@6404##2 9.574
R368 net@6404##2 net@6404##3 9.574
R369 net@6404##3 net@6404##4 9.574
R370 net@6404##4 net@6404##5 9.574
R371 net@6404##5 net@6404##6 9.574
R372 net@6404##6 net@6404##7 9.574
R373 net@6404##7 net@6404##8 9.574
R374 net@6404##8 net@6404##9 9.574
R375 net@6404##9 net@6404##10 9.574
R376 net@6404##10 net@6404##11 9.574
R377 net@6404##11 net@6404##12 9.574
R378 net@6404##12 net@6404##13 9.574
R379 net@6404##13 net@6404##14 9.574
R380 net@6404##14 net@6404##15 9.574
R381 net@6404##15 net@6404#1contact@2374_metal-1-polysilicon-1 9.574
R382 net@6404#1contact@2374_metal-1-polysilicon-1 net@6404#1contact@2374_metal-1-polysilicon-1##0 9.494
R383 net@6404#1contact@2374_metal-1-polysilicon-1##0 net@6404#1contact@2374_metal-1-polysilicon-1##1 9.494
R384 net@6404#1contact@2374_metal-1-polysilicon-1##1 net@6404#1contact@2374_metal-1-polysilicon-1##2 9.494
R385 net@6404#1contact@2374_metal-1-polysilicon-1##2 net@6404#1contact@2374_metal-1-polysilicon-1##3 9.494
R386 net@6404#1contact@2374_metal-1-polysilicon-1##3 net@6404#1contact@2374_metal-1-polysilicon-1##4 9.494
R387 net@6404#1contact@2374_metal-1-polysilicon-1##4 net@6404#1contact@2374_metal-1-polysilicon-1##5 9.494
R388 net@6404#1contact@2374_metal-1-polysilicon-1##5 net@6404#1contact@2374_metal-1-polysilicon-1##6 9.494
R389 net@6404#1contact@2374_metal-1-polysilicon-1##6 net@6404#2nmos@464_poly-left 9.494
R390 net@6395#3contact@2359_metal-1-polysilicon-1 net@6395#3contact@2359_metal-1-polysilicon-1 0
R391 net@6420 net@6420#1pin@1352_polysilicon-1 7.75
R392 net@6420#1pin@1352_polysilicon-1 net@6420#1pin@1352_polysilicon-1##0 9.623
R393 net@6420#1pin@1352_polysilicon-1##0 net@6420#1pin@1352_polysilicon-1##1 9.623
R394 net@6420#1pin@1352_polysilicon-1##1 net@6420#1pin@1352_polysilicon-1##2 9.623
R395 net@6420#1pin@1352_polysilicon-1##2 net@6420#1pin@1352_polysilicon-1##3 9.623
R396 net@6420#1pin@1352_polysilicon-1##3 net@6420#1pin@1352_polysilicon-1##4 9.623
R397 net@6420#1pin@1352_polysilicon-1##4 net@6420#1pin@1352_polysilicon-1##5 9.623
R398 net@6420#1pin@1352_polysilicon-1##5 net@6420#1pin@1352_polysilicon-1##6 9.623
R399 net@6420#1pin@1352_polysilicon-1##6 net@6420#1pin@1352_polysilicon-1##7 9.623
R400 net@6420#1pin@1352_polysilicon-1##7 net@6420#1pin@1352_polysilicon-1##8 9.623
R401 net@6420#1pin@1352_polysilicon-1##8 net@6420#1pin@1352_polysilicon-1##9 9.623
R402 net@6420#1pin@1352_polysilicon-1##9 net@6420#1pin@1352_polysilicon-1##10 9.623
R403 net@6420#1pin@1352_polysilicon-1##10 net@6420#1pin@1352_polysilicon-1##11 9.623
R404 net@6420#1pin@1352_polysilicon-1##11 net@6420#1pin@1352_polysilicon-1##12 9.623
R405 net@6420#1pin@1352_polysilicon-1##12 net@6420#1pin@1352_polysilicon-1##13 9.623
R406 net@6420#1pin@1352_polysilicon-1##13 net@6420#1pin@1352_polysilicon-1##14 9.623
R407 net@6420#1pin@1352_polysilicon-1##14 net@6420#1pin@1352_polysilicon-1##15 9.623
R408 net@6420#1pin@1352_polysilicon-1##15 net@6420#1pin@1352_polysilicon-1##16 9.623
R409 net@6420#1pin@1352_polysilicon-1##16 net@6420#1pin@1352_polysilicon-1##17 9.623
R410 net@6420#1pin@1352_polysilicon-1##17 net@6420#1pin@1352_polysilicon-1##18 9.623
R411 net@6420#1pin@1352_polysilicon-1##18 net@6420#1pin@1352_polysilicon-1##19 9.623
R412 net@6420#1pin@1352_polysilicon-1##19 net@6420#1pin@1352_polysilicon-1##20 9.623
R413 net@6420#1pin@1352_polysilicon-1##20 net@6420#1pin@1352_polysilicon-1##21 9.623
R414 net@6420#1pin@1352_polysilicon-1##21 net@6420#1pin@1352_polysilicon-1##22 9.623
R415 net@6420#1pin@1352_polysilicon-1##22 net@6420#2nmos@479_poly-right 9.623
R416 net@6420#3contact@2438_metal-1-polysilicon-1 net@6420#3contact@2438_metal-1-polysilicon-1##0 8.68
R417 net@6420#3contact@2438_metal-1-polysilicon-1##0 net@6420#3contact@2438_metal-1-polysilicon-1##1 8.68
R418 net@6420#3contact@2438_metal-1-polysilicon-1##1 net@6420#3contact@2438_metal-1-polysilicon-1##2 8.68
R419 net@6420#3contact@2438_metal-1-polysilicon-1##2 net@6420#3contact@2438_metal-1-polysilicon-1##3 8.68
R420 net@6420#3contact@2438_metal-1-polysilicon-1##3 net@6420#1pin@1352_polysilicon-1 8.68
R421 net@6404#4contact@2430_metal-1-n-act net@6404#4contact@2430_metal-1-n-act 0
R422 S1#4pmos@477_poly-right S1#4pmos@477_poly-right##0 9.482
R423 S1#4pmos@477_poly-right##0 S1#4pmos@477_poly-right##1 9.482
R424 S1#4pmos@477_poly-right##1 S1#4pmos@477_poly-right##2 9.482
R425 S1#4pmos@477_poly-right##2 S1#4pmos@477_poly-right##3 9.482
R426 S1#4pmos@477_poly-right##3 S1#4pmos@477_poly-right##4 9.482
R427 S1#4pmos@477_poly-right##4 S1#4pmos@477_poly-right##5 9.482
R428 S1#4pmos@477_poly-right##5 S1#4pmos@477_poly-right##6 9.482
R429 S1#4pmos@477_poly-right##6 S1#4pmos@477_poly-right##7 9.482
R430 S1#4pmos@477_poly-right##7 S1#4pmos@477_poly-right##8 9.482
R431 S1#4pmos@477_poly-right##8 S1#4pmos@477_poly-right##9 9.482
R432 S1#4pmos@477_poly-right##9 S1#4pmos@477_poly-right##10 9.482
R433 S1#4pmos@477_poly-right##10 S1#4pmos@477_poly-right##11 9.482
R434 S1#4pmos@477_poly-right##11 S1#4pmos@477_poly-right##12 9.482
R435 S1#4pmos@477_poly-right##12 S1#4pmos@477_poly-right##13 9.482
R436 S1#4pmos@477_poly-right##13 S1#4pmos@477_poly-right##14 9.482
R437 S1#4pmos@477_poly-right##14 S1#4pmos@477_poly-right##15 9.482
R438 S1#4pmos@477_poly-right##15 S1 9.482
R439 S1 S1##0 9.688
R440 S1##0 S1##1 9.688
R441 S1##1 S1##2 9.688
R442 S1##2 S1##3 9.688
R443 S1##3 S1##4 9.688
R444 S1##4 S1##5 9.688
R445 S1##5 S1##6 9.688
R446 S1##6 S1#6nmos@478_poly-left 9.688
R447 S0#5pmos@480_poly-right S0#5pmos@480_poly-right##0 9.871
R448 S0#5pmos@480_poly-right##0 S0#5pmos@480_poly-right##1 9.871
R449 S0#5pmos@480_poly-right##1 S0#5pmos@480_poly-right##2 9.871
R450 S0#5pmos@480_poly-right##2 S0#5pmos@480_poly-right##3 9.871
R451 S0#5pmos@480_poly-right##3 S0#5pmos@480_poly-right##4 9.871
R452 S0#5pmos@480_poly-right##4 S0#5pmos@480_poly-right##5 9.871
R453 S0#5pmos@480_poly-right##5 S0#5pmos@480_poly-right##6 9.871
R454 S0#5pmos@480_poly-right##6 S0#5pmos@480_poly-right##7 9.871
R455 S0#5pmos@480_poly-right##7 S0#5pmos@480_poly-right##8 9.871
R456 S0#5pmos@480_poly-right##8 S0#5pmos@480_poly-right##9 9.871
R457 S0#5pmos@480_poly-right##9 S0#5pmos@480_poly-right##10 9.871
R458 S0#5pmos@480_poly-right##10 S0#5pmos@480_poly-right##11 9.871
R459 S0#5pmos@480_poly-right##11 S0#5pmos@480_poly-right##12 9.871
R460 S0#5pmos@480_poly-right##12 S0#5pmos@480_poly-right##13 9.871
R461 S0#5pmos@480_poly-right##13 S0#5pmos@480_poly-right##14 9.871
R462 S0#5pmos@480_poly-right##14 S0#5pmos@480_poly-right##15 9.871
R463 S0#5pmos@480_poly-right##15 S0#5pmos@480_poly-right##16 9.871
R464 S0#5pmos@480_poly-right##16 S0#5pmos@480_poly-right##17 9.871
R465 S0#5pmos@480_poly-right##17 S0#6pin@1351_polysilicon-1 9.871
R466 S0#6pin@1351_polysilicon-1 S0#6pin@1351_polysilicon-1##0 8.525
R467 S0#6pin@1351_polysilicon-1##0 S0#6pin@1351_polysilicon-1##1 8.525
R468 S0#6pin@1351_polysilicon-1##1 S0#6pin@1351_polysilicon-1##2 8.525
R469 S0#6pin@1351_polysilicon-1##2 S0#6pin@1351_polysilicon-1##3 8.525
R470 S0#6pin@1351_polysilicon-1##3 S0#6pin@1351_polysilicon-1##4 8.525
R471 S0#6pin@1351_polysilicon-1##4 S0#7nmos@480_poly-left 8.525
R472 S0 S0##0 5.425
R473 S0##0 S0#6pin@1351_polysilicon-1 5.425
R474 net@6315#3contact@2440_metal-1-p-act net@6315#3contact@2440_metal-1-p-act 0
R475 S0#10pmos@482_poly-right S0#10pmos@482_poly-right##0 9.817
R476 S0#10pmos@482_poly-right##0 S0#10pmos@482_poly-right##1 9.817
R477 S0#10pmos@482_poly-right##1 S0#10pmos@482_poly-right##2 9.817
R478 S0#10pmos@482_poly-right##2 S0#10pmos@482_poly-right##3 9.817
R479 S0#10pmos@482_poly-right##3 S0#10pmos@482_poly-right##4 9.817
R480 S0#10pmos@482_poly-right##4 S0#10pmos@482_poly-right##5 9.817
R481 S0#10pmos@482_poly-right##5 S0#10pmos@482_poly-right##6 9.817
R482 S0#10pmos@482_poly-right##6 S0#10pmos@482_poly-right##7 9.817
R483 S0#10pmos@482_poly-right##7 S0#10pmos@482_poly-right##8 9.817
R484 S0#10pmos@482_poly-right##8 S0#10pmos@482_poly-right##9 9.817
R485 S0#10pmos@482_poly-right##9 S0#10pmos@482_poly-right##10 9.817
R486 S0#10pmos@482_poly-right##10 S0#10pmos@482_poly-right##11 9.817
R487 S0#10pmos@482_poly-right##11 S0#10pmos@482_poly-right##12 9.817
R488 S0#10pmos@482_poly-right##12 S0#10pmos@482_poly-right##13 9.817
R489 S0#10pmos@482_poly-right##13 S0#10pmos@482_poly-right##14 9.817
R490 S0#10pmos@482_poly-right##14 S0#10pmos@482_poly-right##15 9.817
R491 S0#10pmos@482_poly-right##15 S0#10pmos@482_poly-right##16 9.817
R492 S0#10pmos@482_poly-right##16 S0#10pmos@482_poly-right##17 9.817
R493 S0#10pmos@482_poly-right##17 S0#10pmos@482_poly-right##18 9.817
R494 S0#10pmos@482_poly-right##18 S0#10pmos@482_poly-right##19 9.817
R495 S0#10pmos@482_poly-right##19 S0#11pin@1353_polysilicon-1 9.817
R496 S0#11pin@1353_polysilicon-1 S0#11pin@1353_polysilicon-1##0 8.138
R497 S0#11pin@1353_polysilicon-1##0 S0#11pin@1353_polysilicon-1##1 8.138
R498 S0#11pin@1353_polysilicon-1##1 S0#11pin@1353_polysilicon-1##2 8.138
R499 S0#11pin@1353_polysilicon-1##2 S0#12nmos@482_poly-right 8.138
R500 S0 S0##0 9.713
R501 S0##0 S0##1 9.713
R502 S0##1 S0##2 9.713
R503 S0##2 S0##3 9.713
R504 S0##3 S0##4 9.713
R505 S0##4 S0##5 9.713
R506 S0##5 S0##6 9.713
R507 S0##6 S0##7 9.713
R508 S0##7 S0##8 9.713
R509 S0##8 S0##9 9.713
R510 S0##9 S0##10 9.713
R511 S0##10 S0##11 9.713
R512 S0##11 S0##12 9.713
R513 S0##12 S0##13 9.713
R514 S0##13 S0#11pin@1353_polysilicon-1 9.713
R515 net@6360#3contact@2421_metal-1-polysilicon-1 net@6360#3contact@2421_metal-1-polysilicon-1 0
R516 S1#11pmos@481_poly-right S1#11pmos@481_poly-right##0 9.623
R517 S1#11pmos@481_poly-right##0 S1#11pmos@481_poly-right##1 9.623
R518 S1#11pmos@481_poly-right##1 S1#11pmos@481_poly-right##2 9.623
R519 S1#11pmos@481_poly-right##2 S1#11pmos@481_poly-right##3 9.623
R520 S1#11pmos@481_poly-right##3 S1#11pmos@481_poly-right##4 9.623
R521 S1#11pmos@481_poly-right##4 S1#11pmos@481_poly-right##5 9.623
R522 S1#11pmos@481_poly-right##5 S1#11pmos@481_poly-right##6 9.623
R523 S1#11pmos@481_poly-right##6 S1#11pmos@481_poly-right##7 9.623
R524 S1#11pmos@481_poly-right##7 S1#11pmos@481_poly-right##8 9.623
R525 S1#11pmos@481_poly-right##8 S1#11pmos@481_poly-right##9 9.623
R526 S1#11pmos@481_poly-right##9 S1#11pmos@481_poly-right##10 9.623
R527 S1#11pmos@481_poly-right##10 S1#11pmos@481_poly-right##11 9.623
R528 S1#11pmos@481_poly-right##11 S1#11pmos@481_poly-right##12 9.623
R529 S1#11pmos@481_poly-right##12 S1#11pmos@481_poly-right##13 9.623
R530 S1#11pmos@481_poly-right##13 S1#11pmos@481_poly-right##14 9.623
R531 S1#11pmos@481_poly-right##14 S1#11pmos@481_poly-right##15 9.623
R532 S1#11pmos@481_poly-right##15 S1#11pmos@481_poly-right##16 9.623
R533 S1#11pmos@481_poly-right##16 S1#11pmos@481_poly-right##17 9.623
R534 S1#11pmos@481_poly-right##17 S1#11pmos@481_poly-right##18 9.623
R535 S1#11pmos@481_poly-right##18 S1#11pmos@481_poly-right##19 9.623
R536 S1#11pmos@481_poly-right##19 S1#11pmos@481_poly-right##20 9.623
R537 S1#11pmos@481_poly-right##20 S1#11pmos@481_poly-right##21 9.623
R538 S1#11pmos@481_poly-right##21 S1#11pmos@481_poly-right##22 9.623
R539 S1#11pmos@481_poly-right##22 S1#12pin@1354_polysilicon-1 9.623
R540 S1#12pin@1354_polysilicon-1 S1#13nmos@481_poly-right 7.75
R541 S1 S1##0 6.2
R542 S1##0 S1#12pin@1354_polysilicon-1 6.2
R543 D3#3nmos@477_poly-left D3#3nmos@477_poly-left##0 9.92
R544 D3#3nmos@477_poly-left##0 D3#3nmos@477_poly-left##1 9.92
R545 D3#3nmos@477_poly-left##1 D3#3nmos@477_poly-left##2 9.92
R546 D3#3nmos@477_poly-left##2 D3#3nmos@477_poly-left##3 9.92
R547 D3#3nmos@477_poly-left##3 D3#3nmos@477_poly-left##4 9.92
R548 D3#3nmos@477_poly-left##4 D3#3nmos@477_poly-left##5 9.92
R549 D3#3nmos@477_poly-left##5 D3#3nmos@477_poly-left##6 9.92
R550 D3#3nmos@477_poly-left##6 D3#3nmos@477_poly-left##7 9.92
R551 D3#3nmos@477_poly-left##7 D3#3nmos@477_poly-left##8 9.92
R552 D3#3nmos@477_poly-left##8 D3#4pin@1355_polysilicon-1 9.92
R553 D3#4pin@1355_polysilicon-1 D3#4pin@1355_polysilicon-1##0 9.964
R554 D3#4pin@1355_polysilicon-1##0 D3#4pin@1355_polysilicon-1##1 9.964
R555 D3#4pin@1355_polysilicon-1##1 D3#4pin@1355_polysilicon-1##2 9.964
R556 D3#4pin@1355_polysilicon-1##2 D3#4pin@1355_polysilicon-1##3 9.964
R557 D3#4pin@1355_polysilicon-1##3 D3#4pin@1355_polysilicon-1##4 9.964
R558 D3#4pin@1355_polysilicon-1##4 D3#4pin@1355_polysilicon-1##5 9.964
R559 D3#4pin@1355_polysilicon-1##5 D3#4pin@1355_polysilicon-1##6 9.964
R560 D3#4pin@1355_polysilicon-1##6 D3#4pin@1355_polysilicon-1##7 9.964
R561 D3#4pin@1355_polysilicon-1##7 D3#4pin@1355_polysilicon-1##8 9.964
R562 D3#4pin@1355_polysilicon-1##8 D3#4pin@1355_polysilicon-1##9 9.964
R563 D3#4pin@1355_polysilicon-1##9 D3#4pin@1355_polysilicon-1##10 9.964
R564 D3#4pin@1355_polysilicon-1##10 D3#4pin@1355_polysilicon-1##11 9.964
R565 D3#4pin@1355_polysilicon-1##11 D3#4pin@1355_polysilicon-1##12 9.964
R566 D3#4pin@1355_polysilicon-1##12 D3#5pmos@478_poly-right 9.964
R567 D3 D3##0 8.06
R568 D3##0 D3##1 8.06
R569 D3##1 D3##2 8.06
R570 D3##2 D3##3 8.06
R571 D3##3 D3#4pin@1355_polysilicon-1 8.06
R572 D2 D2#3contact@2409_metal-1-polysilicon-1 4.576
R573 net@6315#3contact@2440_metal-1-p-act net@6315#1contact@2403_metal-1-polysilicon-1 4.706
R574 D1 D1#3contact@2393_metal-1-polysilicon-1 6.838
R575 D0#0contact@2468_metal-1-metal-2 D0 9.087
R576 net@6333 net@6333#5contact@2373_metal-1-polysilicon-1 5.07
R577 S0#3contact@2405_metal-1-polysilicon-1 S0 4.68
R578 net@6404#4contact@2430_metal-1-n-act net@6404#1contact@2374_metal-1-polysilicon-1 7.254
R579 D0#3nmos@465_poly-left D0#3nmos@465_poly-left##0 9.723
R580 D0#3nmos@465_poly-left##0 D0#3nmos@465_poly-left##1 9.723
R581 D0#3nmos@465_poly-left##1 D0#3nmos@465_poly-left##2 9.723
R582 D0#3nmos@465_poly-left##2 D0#3nmos@465_poly-left##3 9.723
R583 D0#3nmos@465_poly-left##3 D0#3nmos@465_poly-left##4 9.723
R584 D0#3nmos@465_poly-left##4 D0#3nmos@465_poly-left##5 9.723
R585 D0#3nmos@465_poly-left##5 D0#3nmos@465_poly-left##6 9.723
R586 D0#3nmos@465_poly-left##6 D0#3nmos@465_poly-left##7 9.723
R587 D0#3nmos@465_poly-left##7 D0#3nmos@465_poly-left##8 9.723
R588 D0#3nmos@465_poly-left##8 D0#3nmos@465_poly-left##9 9.723
R589 D0#3nmos@465_poly-left##9 D0#3nmos@465_poly-left##10 9.723
R590 D0#3nmos@465_poly-left##10 D0#3nmos@465_poly-left##11 9.723
R591 D0#3nmos@465_poly-left##11 D0#3nmos@465_poly-left##12 9.723
R592 D0#3nmos@465_poly-left##12 D0#3nmos@465_poly-left##13 9.723
R593 D0#3nmos@465_poly-left##13 D0#3nmos@465_poly-left##14 9.723
R594 D0#3nmos@465_poly-left##14 D0#3nmos@465_poly-left##15 9.723
R595 D0#3nmos@465_poly-left##15 D0#3nmos@465_poly-left##16 9.723
R596 D0#3nmos@465_poly-left##16 D0#3nmos@465_poly-left##17 9.723
R597 D0#3nmos@465_poly-left##17 D0#3nmos@465_poly-left##18 9.723
R598 D0#3nmos@465_poly-left##18 D0#3nmos@465_poly-left##19 9.723
R599 D0#3nmos@465_poly-left##19 D0#3nmos@465_poly-left##20 9.723
R600 D0#3nmos@465_poly-left##20 D0#4pin@1322_polysilicon-1 9.723
R601 D0#4pin@1322_polysilicon-1 D0#4pin@1322_polysilicon-1##0 8.267
R602 D0#4pin@1322_polysilicon-1##0 D0#4pin@1322_polysilicon-1##1 8.267
R603 D0#4pin@1322_polysilicon-1##1 D0#5pmos@466_poly-right 8.267
R604 D0#0contact@2468_metal-1-metal-2 D0#0contact@2468_metal-1-metal-2##0 8.138
R605 D0#0contact@2468_metal-1-metal-2##0 D0#0contact@2468_metal-1-metal-2##1 8.138
R606 D0#0contact@2468_metal-1-metal-2##1 D0#0contact@2468_metal-1-metal-2##2 8.138
R607 D0#0contact@2468_metal-1-metal-2##2 D0#4pin@1322_polysilicon-1 8.138
R608 net@6360#16pmos@465_poly-right net@6360#16pmos@465_poly-right##0 9.817
R609 net@6360#16pmos@465_poly-right##0 net@6360#16pmos@465_poly-right##1 9.817
R610 net@6360#16pmos@465_poly-right##1 net@6360#16pmos@465_poly-right##2 9.817
R611 net@6360#16pmos@465_poly-right##2 net@6360#16pmos@465_poly-right##3 9.817
R612 net@6360#16pmos@465_poly-right##3 net@6360#16pmos@465_poly-right##4 9.817
R613 net@6360#16pmos@465_poly-right##4 net@6360#16pmos@465_poly-right##5 9.817
R614 net@6360#16pmos@465_poly-right##5 net@6360#16pmos@465_poly-right##6 9.817
R615 net@6360#16pmos@465_poly-right##6 net@6360#16pmos@465_poly-right##7 9.817
R616 net@6360#16pmos@465_poly-right##7 net@6360#16pmos@465_poly-right##8 9.817
R617 net@6360#16pmos@465_poly-right##8 net@6360#16pmos@465_poly-right##9 9.817
R618 net@6360#16pmos@465_poly-right##9 net@6360#16pmos@465_poly-right##10 9.817
R619 net@6360#16pmos@465_poly-right##10 net@6360#3contact@2421_metal-1-polysilicon-1 9.817
R620 net@6360#3contact@2421_metal-1-polysilicon-1 net@6360#3contact@2421_metal-1-polysilicon-1##0 9.3
R621 net@6360#3contact@2421_metal-1-polysilicon-1##0 net@6360#3contact@2421_metal-1-polysilicon-1##1 9.3
R622 net@6360#3contact@2421_metal-1-polysilicon-1##1 net@6360#3contact@2421_metal-1-polysilicon-1##2 9.3
R623 net@6360#3contact@2421_metal-1-polysilicon-1##2 net@6360#3contact@2421_metal-1-polysilicon-1##3 9.3
R624 net@6360#3contact@2421_metal-1-polysilicon-1##3 net@6360#3contact@2421_metal-1-polysilicon-1##4 9.3
R625 net@6360#3contact@2421_metal-1-polysilicon-1##4 net@6360#3contact@2421_metal-1-polysilicon-1##5 9.3
R626 net@6360#3contact@2421_metal-1-polysilicon-1##5 net@6360#3contact@2421_metal-1-polysilicon-1##6 9.3
R627 net@6360#3contact@2421_metal-1-polysilicon-1##6 net@6360#3contact@2421_metal-1-polysilicon-1##7 9.3
R628 net@6360#3contact@2421_metal-1-polysilicon-1##7 net@6360#3contact@2421_metal-1-polysilicon-1##8 9.3
R629 net@6360#3contact@2421_metal-1-polysilicon-1##8 net@6360#3contact@2421_metal-1-polysilicon-1##9 9.3
R630 net@6360#3contact@2421_metal-1-polysilicon-1##9 net@6360#3contact@2421_metal-1-polysilicon-1##10 9.3
R631 net@6360#3contact@2421_metal-1-polysilicon-1##10 net@6360#3contact@2421_metal-1-polysilicon-1##11 9.3
R632 net@6360#3contact@2421_metal-1-polysilicon-1##11 net@6360#18nmos@466_poly-left 9.3
R633 net@6315#13pmos@468_poly-right net@6315#13pmos@468_poly-right##0 9.403
R634 net@6315#13pmos@468_poly-right##0 net@6315#13pmos@468_poly-right##1 9.403
R635 net@6315#13pmos@468_poly-right##1 net@6315#13pmos@468_poly-right##2 9.403
R636 net@6315#13pmos@468_poly-right##2 net@6315#13pmos@468_poly-right##3 9.403
R637 net@6315#13pmos@468_poly-right##3 net@6315#13pmos@468_poly-right##4 9.403
R638 net@6315#13pmos@468_poly-right##4 net@6315#13pmos@468_poly-right##5 9.403
R639 net@6315#13pmos@468_poly-right##5 net@6315#13pmos@468_poly-right##6 9.403
R640 net@6315#13pmos@468_poly-right##6 net@6315#13pmos@468_poly-right##7 9.403
R641 net@6315#13pmos@468_poly-right##7 net@6315#13pmos@468_poly-right##8 9.403
R642 net@6315#13pmos@468_poly-right##8 net@6315#13pmos@468_poly-right##9 9.403
R643 net@6315#13pmos@468_poly-right##9 net@6315#13pmos@468_poly-right##10 9.403
R644 net@6315#13pmos@468_poly-right##10 net@6315#13pmos@468_poly-right##11 9.403
R645 net@6315#13pmos@468_poly-right##11 net@6315#13pmos@468_poly-right##12 9.403
R646 net@6315#13pmos@468_poly-right##12 net@6315#13pmos@468_poly-right##13 9.403
R647 net@6315#13pmos@468_poly-right##13 net@6315#14pin@1328_polysilicon-1 9.403
R648 net@6315#14pin@1328_polysilicon-1 net@6315#14pin@1328_polysilicon-1##0 9.765
R649 net@6315#14pin@1328_polysilicon-1##0 net@6315#14pin@1328_polysilicon-1##1 9.765
R650 net@6315#14pin@1328_polysilicon-1##1 net@6315#14pin@1328_polysilicon-1##2 9.765
R651 net@6315#14pin@1328_polysilicon-1##2 net@6315#14pin@1328_polysilicon-1##3 9.765
R652 net@6315#14pin@1328_polysilicon-1##3 net@6315#14pin@1328_polysilicon-1##4 9.765
R653 net@6315#14pin@1328_polysilicon-1##4 net@6315#14pin@1328_polysilicon-1##5 9.765
R654 net@6315#14pin@1328_polysilicon-1##5 net@6315#14pin@1328_polysilicon-1##6 9.765
R655 net@6315#14pin@1328_polysilicon-1##6 net@6315#14pin@1328_polysilicon-1##7 9.765
R656 net@6315#14pin@1328_polysilicon-1##7 net@6315#14pin@1328_polysilicon-1##8 9.765
R657 net@6315#14pin@1328_polysilicon-1##8 net@6315#15nmos@468_poly-left 9.765
R658 net@6315#1contact@2403_metal-1-polysilicon-1 net@6315#1contact@2403_metal-1-polysilicon-1##0 5.425
R659 net@6315#1contact@2403_metal-1-polysilicon-1##0 net@6315#14pin@1328_polysilicon-1 5.425
R660 net@6592 net@6592#1pin@1394_polysilicon-1 7.75
R661 net@6592#1pin@1394_polysilicon-1 net@6592#1pin@1394_polysilicon-1##0 9.623
R662 net@6592#1pin@1394_polysilicon-1##0 net@6592#1pin@1394_polysilicon-1##1 9.623
R663 net@6592#1pin@1394_polysilicon-1##1 net@6592#1pin@1394_polysilicon-1##2 9.623
R664 net@6592#1pin@1394_polysilicon-1##2 net@6592#1pin@1394_polysilicon-1##3 9.623
R665 net@6592#1pin@1394_polysilicon-1##3 net@6592#1pin@1394_polysilicon-1##4 9.623
R666 net@6592#1pin@1394_polysilicon-1##4 net@6592#1pin@1394_polysilicon-1##5 9.623
R667 net@6592#1pin@1394_polysilicon-1##5 net@6592#1pin@1394_polysilicon-1##6 9.623
R668 net@6592#1pin@1394_polysilicon-1##6 net@6592#1pin@1394_polysilicon-1##7 9.623
R669 net@6592#1pin@1394_polysilicon-1##7 net@6592#1pin@1394_polysilicon-1##8 9.623
R670 net@6592#1pin@1394_polysilicon-1##8 net@6592#1pin@1394_polysilicon-1##9 9.623
R671 net@6592#1pin@1394_polysilicon-1##9 net@6592#1pin@1394_polysilicon-1##10 9.623
R672 net@6592#1pin@1394_polysilicon-1##10 net@6592#1pin@1394_polysilicon-1##11 9.623
R673 net@6592#1pin@1394_polysilicon-1##11 net@6592#1pin@1394_polysilicon-1##12 9.623
R674 net@6592#1pin@1394_polysilicon-1##12 net@6592#1pin@1394_polysilicon-1##13 9.623
R675 net@6592#1pin@1394_polysilicon-1##13 net@6592#1pin@1394_polysilicon-1##14 9.623
R676 net@6592#1pin@1394_polysilicon-1##14 net@6592#1pin@1394_polysilicon-1##15 9.623
R677 net@6592#1pin@1394_polysilicon-1##15 net@6592#1pin@1394_polysilicon-1##16 9.623
R678 net@6592#1pin@1394_polysilicon-1##16 net@6592#1pin@1394_polysilicon-1##17 9.623
R679 net@6592#1pin@1394_polysilicon-1##17 net@6592#1pin@1394_polysilicon-1##18 9.623
R680 net@6592#1pin@1394_polysilicon-1##18 net@6592#1pin@1394_polysilicon-1##19 9.623
R681 net@6592#1pin@1394_polysilicon-1##19 net@6592#1pin@1394_polysilicon-1##20 9.623
R682 net@6592#1pin@1394_polysilicon-1##20 net@6592#1pin@1394_polysilicon-1##21 9.623
R683 net@6592#1pin@1394_polysilicon-1##21 net@6592#1pin@1394_polysilicon-1##22 9.623
R684 net@6592#1pin@1394_polysilicon-1##22 net@6592#2nmos@490_poly-right 9.623
R685 net@6592#3contact@2508_metal-1-polysilicon-1 net@6592#3contact@2508_metal-1-polysilicon-1##0 8.68
R686 net@6592#3contact@2508_metal-1-polysilicon-1##0 net@6592#3contact@2508_metal-1-polysilicon-1##1 8.68
R687 net@6592#3contact@2508_metal-1-polysilicon-1##1 net@6592#3contact@2508_metal-1-polysilicon-1##2 8.68
R688 net@6592#3contact@2508_metal-1-polysilicon-1##2 net@6592#3contact@2508_metal-1-polysilicon-1##3 8.68
R689 net@6592#3contact@2508_metal-1-polysilicon-1##3 net@6592#1pin@1394_polysilicon-1 8.68
R690 net@6596 net@6596 0
R691 D5#0nmos@492_poly-left D5#0nmos@492_poly-left##0 9.953
R692 D5#0nmos@492_poly-left##0 D5#0nmos@492_poly-left##1 9.953
R693 D5#0nmos@492_poly-left##1 D5#0nmos@492_poly-left##2 9.953
R694 D5#0nmos@492_poly-left##2 D5#0nmos@492_poly-left##3 9.953
R695 D5#0nmos@492_poly-left##3 D5#0nmos@492_poly-left##4 9.953
R696 D5#0nmos@492_poly-left##4 D5#0nmos@492_poly-left##5 9.953
R697 D5#0nmos@492_poly-left##5 D5#0nmos@492_poly-left##6 9.953
R698 D5#0nmos@492_poly-left##6 D5#0nmos@492_poly-left##7 9.953
R699 D5#0nmos@492_poly-left##7 D5#0nmos@492_poly-left##8 9.953
R700 D5#0nmos@492_poly-left##8 D5#0nmos@492_poly-left##9 9.953
R701 D5#0nmos@492_poly-left##9 D5#0nmos@492_poly-left##10 9.953
R702 D5#0nmos@492_poly-left##10 D5#0nmos@492_poly-left##11 9.953
R703 D5#0nmos@492_poly-left##11 D5#0nmos@492_poly-left##12 9.953
R704 D5#0nmos@492_poly-left##12 D5#0nmos@492_poly-left##13 9.953
R705 D5#0nmos@492_poly-left##13 D5#0nmos@492_poly-left##14 9.953
R706 D5#0nmos@492_poly-left##14 D5#0nmos@492_poly-left##15 9.953
R707 D5#0nmos@492_poly-left##15 D5#0nmos@492_poly-left##16 9.953
R708 D5#0nmos@492_poly-left##16 D5#0nmos@492_poly-left##17 9.953
R709 D5#0nmos@492_poly-left##17 D5#1pin@1395_polysilicon-1 9.953
R710 D5#1pin@1395_polysilicon-1 D5#1pin@1395_polysilicon-1##0 9.92
R711 D5#1pin@1395_polysilicon-1##0 D5#1pin@1395_polysilicon-1##1 9.92
R712 D5#1pin@1395_polysilicon-1##1 D5#1pin@1395_polysilicon-1##2 9.92
R713 D5#1pin@1395_polysilicon-1##2 D5#1pin@1395_polysilicon-1##3 9.92
R714 D5#1pin@1395_polysilicon-1##3 D5#2pmos@493_poly-right 9.92
R715 D5#3contact@2511_metal-1-polysilicon-1 D5#3contact@2511_metal-1-polysilicon-1##0 8.525
R716 D5#3contact@2511_metal-1-polysilicon-1##0 D5#3contact@2511_metal-1-polysilicon-1##1 8.525
R717 D5#3contact@2511_metal-1-polysilicon-1##1 D5#3contact@2511_metal-1-polysilicon-1##2 8.525
R718 D5#3contact@2511_metal-1-polysilicon-1##2 D5#1pin@1395_polysilicon-1 8.525
R719 net@6614 net@6614##0 9.545
R720 net@6614##0 net@6614##1 9.545
R721 net@6614##1 net@6614##2 9.545
R722 net@6614##2 net@6614##3 9.545
R723 net@6614##3 net@6614##4 9.545
R724 net@6614##4 net@6614##5 9.545
R725 net@6614##5 net@6614##6 9.545
R726 net@6614##6 net@6614##7 9.545
R727 net@6614##7 net@6614##8 9.545
R728 net@6614##8 net@6614##9 9.545
R729 net@6614##9 net@6614##10 9.545
R730 net@6614##10 net@6614##11 9.545
R731 net@6614##11 net@6614##12 9.545
R732 net@6614##12 net@6614##13 9.545
R733 net@6614##13 net@6614##14 9.545
R734 net@6614##14 net@6614##15 9.545
R735 net@6614##15 net@6614##16 9.545
R736 net@6614##16 net@6614##17 9.545
R737 net@6614##17 net@6614#1contact@2521_metal-1-polysilicon-1 9.545
R738 net@6614#1contact@2521_metal-1-polysilicon-1 net@6614#1contact@2521_metal-1-polysilicon-1##0 9.558
R739 net@6614#1contact@2521_metal-1-polysilicon-1##0 net@6614#1contact@2521_metal-1-polysilicon-1##1 9.558
R740 net@6614#1contact@2521_metal-1-polysilicon-1##1 net@6614#1contact@2521_metal-1-polysilicon-1##2 9.558
R741 net@6614#1contact@2521_metal-1-polysilicon-1##2 net@6614#1contact@2521_metal-1-polysilicon-1##3 9.558
R742 net@6614#1contact@2521_metal-1-polysilicon-1##3 net@6614#1contact@2521_metal-1-polysilicon-1##4 9.558
R743 net@6614#1contact@2521_metal-1-polysilicon-1##4 net@6614#2nmos@493_poly-left 9.558
R744 S0#18pmos@495_poly-right S0#18pmos@495_poly-right##0 9.743
R745 S0#18pmos@495_poly-right##0 S0#18pmos@495_poly-right##1 9.743
R746 S0#18pmos@495_poly-right##1 S0#18pmos@495_poly-right##2 9.743
R747 S0#18pmos@495_poly-right##2 S0#18pmos@495_poly-right##3 9.743
R748 S0#18pmos@495_poly-right##3 S0#18pmos@495_poly-right##4 9.743
R749 S0#18pmos@495_poly-right##4 S0#18pmos@495_poly-right##5 9.743
R750 S0#18pmos@495_poly-right##5 S0#18pmos@495_poly-right##6 9.743
R751 S0#18pmos@495_poly-right##6 S0#18pmos@495_poly-right##7 9.743
R752 S0#18pmos@495_poly-right##7 S0#18pmos@495_poly-right##8 9.743
R753 S0#18pmos@495_poly-right##8 S0#18pmos@495_poly-right##9 9.743
R754 S0#18pmos@495_poly-right##9 S0#18pmos@495_poly-right##10 9.743
R755 S0#18pmos@495_poly-right##10 S0#18pmos@495_poly-right##11 9.743
R756 S0#18pmos@495_poly-right##11 S0#18pmos@495_poly-right##12 9.743
R757 S0#18pmos@495_poly-right##12 S0#18pmos@495_poly-right##13 9.743
R758 S0#18pmos@495_poly-right##13 S0#18pmos@495_poly-right##14 9.743
R759 S0#18pmos@495_poly-right##14 S0#18pmos@495_poly-right##15 9.743
R760 S0#18pmos@495_poly-right##15 S0#18pmos@495_poly-right##16 9.743
R761 S0#18pmos@495_poly-right##16 S0#18pmos@495_poly-right##17 9.743
R762 S0#18pmos@495_poly-right##17 S0#18pmos@495_poly-right##18 9.743
R763 S0#18pmos@495_poly-right##18 S0#18pmos@495_poly-right##19 9.743
R764 S0#18pmos@495_poly-right##19 S0#19pin@1401_polysilicon-1 9.743
R765 S0#19pin@1401_polysilicon-1 S0#19pin@1401_polysilicon-1##0 8.525
R766 S0#19pin@1401_polysilicon-1##0 S0#19pin@1401_polysilicon-1##1 8.525
R767 S0#19pin@1401_polysilicon-1##1 S0#19pin@1401_polysilicon-1##2 8.525
R768 S0#19pin@1401_polysilicon-1##2 S0#20nmos@495_poly-left 8.525
R769 S0#21contact@2523_metal-1-polysilicon-1 S0#21contact@2523_metal-1-polysilicon-1##0 5.425
R770 S0#21contact@2523_metal-1-polysilicon-1##0 S0#19pin@1401_polysilicon-1 5.425
R771 net@6603#10pmos@494_poly-right net@6603#11pin@1402_polysilicon-1 6.2
R772 net@6603#11pin@1402_polysilicon-1 net@6603#11pin@1402_polysilicon-1##0 9.688
R773 net@6603#11pin@1402_polysilicon-1##0 net@6603#11pin@1402_polysilicon-1##1 9.688
R774 net@6603#11pin@1402_polysilicon-1##1 net@6603#11pin@1402_polysilicon-1##2 9.688
R775 net@6603#11pin@1402_polysilicon-1##2 net@6603#11pin@1402_polysilicon-1##3 9.688
R776 net@6603#11pin@1402_polysilicon-1##3 net@6603#11pin@1402_polysilicon-1##4 9.688
R777 net@6603#11pin@1402_polysilicon-1##4 net@6603#11pin@1402_polysilicon-1##5 9.688
R778 net@6603#11pin@1402_polysilicon-1##5 net@6603#11pin@1402_polysilicon-1##6 9.688
R779 net@6603#11pin@1402_polysilicon-1##6 net@6603#11pin@1402_polysilicon-1##7 9.688
R780 net@6603#11pin@1402_polysilicon-1##7 net@6603#11pin@1402_polysilicon-1##8 9.688
R781 net@6603#11pin@1402_polysilicon-1##8 net@6603#11pin@1402_polysilicon-1##9 9.688
R782 net@6603#11pin@1402_polysilicon-1##9 net@6603#11pin@1402_polysilicon-1##10 9.688
R783 net@6603#11pin@1402_polysilicon-1##10 net@6603#11pin@1402_polysilicon-1##11 9.688
R784 net@6603#11pin@1402_polysilicon-1##11 net@6603#11pin@1402_polysilicon-1##12 9.688
R785 net@6603#11pin@1402_polysilicon-1##12 net@6603#11pin@1402_polysilicon-1##13 9.688
R786 net@6603#11pin@1402_polysilicon-1##13 net@6603#11pin@1402_polysilicon-1##14 9.688
R787 net@6603#11pin@1402_polysilicon-1##14 net@6603#11pin@1402_polysilicon-1##15 9.688
R788 net@6603#11pin@1402_polysilicon-1##15 net@6603#11pin@1402_polysilicon-1##16 9.688
R789 net@6603#11pin@1402_polysilicon-1##16 net@6603#11pin@1402_polysilicon-1##17 9.688
R790 net@6603#11pin@1402_polysilicon-1##17 net@6603#11pin@1402_polysilicon-1##18 9.688
R791 net@6603#11pin@1402_polysilicon-1##18 net@6603#11pin@1402_polysilicon-1##19 9.688
R792 net@6603#11pin@1402_polysilicon-1##19 net@6603#11pin@1402_polysilicon-1##20 9.688
R793 net@6603#11pin@1402_polysilicon-1##20 net@6603#11pin@1402_polysilicon-1##21 9.688
R794 net@6603#11pin@1402_polysilicon-1##21 net@6603#11pin@1402_polysilicon-1##22 9.688
R795 net@6603#11pin@1402_polysilicon-1##22 net@6603#12nmos@494_poly-right 9.688
R796 net@6603 net@6603##0 8.68
R797 net@6603##0 net@6603##1 8.68
R798 net@6603##1 net@6603##2 8.68
R799 net@6603##2 net@6603##3 8.68
R800 net@6603##3 net@6603#11pin@1402_polysilicon-1 8.68
R801 net@6632 net@6632 0
R802 D6#0nmos@496_poly-left D6#0nmos@496_poly-left##0 9.665
R803 D6#0nmos@496_poly-left##0 D6#0nmos@496_poly-left##1 9.665
R804 D6#0nmos@496_poly-left##1 D6#0nmos@496_poly-left##2 9.665
R805 D6#0nmos@496_poly-left##2 D6#0nmos@496_poly-left##3 9.665
R806 D6#0nmos@496_poly-left##3 D6#0nmos@496_poly-left##4 9.665
R807 D6#0nmos@496_poly-left##4 D6#0nmos@496_poly-left##5 9.665
R808 D6#0nmos@496_poly-left##5 D6#0nmos@496_poly-left##6 9.665
R809 D6#0nmos@496_poly-left##6 D6#0nmos@496_poly-left##7 9.665
R810 D6#0nmos@496_poly-left##7 D6#0nmos@496_poly-left##8 9.665
R811 D6#0nmos@496_poly-left##8 D6#0nmos@496_poly-left##9 9.665
R812 D6#0nmos@496_poly-left##9 D6#0nmos@496_poly-left##10 9.665
R813 D6#0nmos@496_poly-left##10 D6#0nmos@496_poly-left##11 9.665
R814 D6#0nmos@496_poly-left##11 D6#0nmos@496_poly-left##12 9.665
R815 D6#0nmos@496_poly-left##12 D6#0nmos@496_poly-left##13 9.665
R816 D6#0nmos@496_poly-left##13 D6#0nmos@496_poly-left##14 9.665
R817 D6#0nmos@496_poly-left##14 D6#0nmos@496_poly-left##15 9.665
R818 D6#0nmos@496_poly-left##15 D6#1pin@1403_polysilicon-1 9.665
R819 D6#1pin@1403_polysilicon-1 D6#1pin@1403_polysilicon-1##0 9.3
R820 D6#1pin@1403_polysilicon-1##0 D6#1pin@1403_polysilicon-1##1 9.3
R821 D6#1pin@1403_polysilicon-1##1 D6#1pin@1403_polysilicon-1##2 9.3
R822 D6#1pin@1403_polysilicon-1##2 D6#1pin@1403_polysilicon-1##3 9.3
R823 D6#1pin@1403_polysilicon-1##3 D6#1pin@1403_polysilicon-1##4 9.3
R824 D6#1pin@1403_polysilicon-1##4 D6#1pin@1403_polysilicon-1##5 9.3
R825 D6#1pin@1403_polysilicon-1##5 D6#1pin@1403_polysilicon-1##6 9.3
R826 D6#1pin@1403_polysilicon-1##6 D6#2pmos@497_poly-right 9.3
R827 D6#3contact@2527_metal-1-polysilicon-1 D6#3contact@2527_metal-1-polysilicon-1##0 9.688
R828 D6#3contact@2527_metal-1-polysilicon-1##0 D6#3contact@2527_metal-1-polysilicon-1##1 9.688
R829 D6#3contact@2527_metal-1-polysilicon-1##1 D6#3contact@2527_metal-1-polysilicon-1##2 9.688
R830 D6#3contact@2527_metal-1-polysilicon-1##2 D6#1pin@1403_polysilicon-1 9.688
R831 S1#17pmos@496_poly-right S1#17pmos@496_poly-right##0 9.3
R832 S1#17pmos@496_poly-right##0 S1#17pmos@496_poly-right##1 9.3
R833 S1#17pmos@496_poly-right##1 S1#17pmos@496_poly-right##2 9.3
R834 S1#17pmos@496_poly-right##2 S1#17pmos@496_poly-right##3 9.3
R835 S1#17pmos@496_poly-right##3 S1#17pmos@496_poly-right##4 9.3
R836 S1#17pmos@496_poly-right##4 S1#17pmos@496_poly-right##5 9.3
R837 S1#17pmos@496_poly-right##5 S1#17pmos@496_poly-right##6 9.3
R838 S1#17pmos@496_poly-right##6 S1#17pmos@496_poly-right##7 9.3
R839 S1#17pmos@496_poly-right##7 S1#17pmos@496_poly-right##8 9.3
R840 S1#17pmos@496_poly-right##8 S1 9.3
R841 S1 S1##0 9.713
R842 S1##0 S1##1 9.713
R843 S1##1 S1##2 9.713
R844 S1##2 S1##3 9.713
R845 S1##3 S1##4 9.713
R846 S1##4 S1##5 9.713
R847 S1##5 S1##6 9.713
R848 S1##6 S1##7 9.713
R849 S1##7 S1##8 9.713
R850 S1##8 S1##9 9.713
R851 S1##9 S1##10 9.713
R852 S1##10 S1##11 9.713
R853 S1##11 S1##12 9.713
R854 S1##12 S1##13 9.713
R855 S1##13 S1#19nmos@497_poly-left 9.713
R856 net@6659 net@6659##0 9.817
R857 net@6659##0 net@6659##1 9.817
R858 net@6659##1 net@6659##2 9.817
R859 net@6659##2 net@6659##3 9.817
R860 net@6659##3 net@6659##4 9.817
R861 net@6659##4 net@6659##5 9.817
R862 net@6659##5 net@6659##6 9.817
R863 net@6659##6 net@6659##7 9.817
R864 net@6659##7 net@6659##8 9.817
R865 net@6659##8 net@6659##9 9.817
R866 net@6659##9 net@6659##10 9.817
R867 net@6659##10 net@6659#1pin@1409_polysilicon-1 9.817
R868 net@6659#1pin@1409_polysilicon-1 net@6659#1pin@1409_polysilicon-1##0 9.3
R869 net@6659#1pin@1409_polysilicon-1##0 net@6659#1pin@1409_polysilicon-1##1 9.3
R870 net@6659#1pin@1409_polysilicon-1##1 net@6659#1pin@1409_polysilicon-1##2 9.3
R871 net@6659#1pin@1409_polysilicon-1##2 net@6659#1pin@1409_polysilicon-1##3 9.3
R872 net@6659#1pin@1409_polysilicon-1##3 net@6659#1pin@1409_polysilicon-1##4 9.3
R873 net@6659#1pin@1409_polysilicon-1##4 net@6659#1pin@1409_polysilicon-1##5 9.3
R874 net@6659#1pin@1409_polysilicon-1##5 net@6659#1pin@1409_polysilicon-1##6 9.3
R875 net@6659#1pin@1409_polysilicon-1##6 net@6659#1pin@1409_polysilicon-1##7 9.3
R876 net@6659#1pin@1409_polysilicon-1##7 net@6659#1pin@1409_polysilicon-1##8 9.3
R877 net@6659#1pin@1409_polysilicon-1##8 net@6659#1pin@1409_polysilicon-1##9 9.3
R878 net@6659#1pin@1409_polysilicon-1##9 net@6659#1pin@1409_polysilicon-1##10 9.3
R879 net@6659#1pin@1409_polysilicon-1##10 net@6659#1pin@1409_polysilicon-1##11 9.3
R880 net@6659#1pin@1409_polysilicon-1##11 net@6659#2nmos@499_poly-left 9.3
R881 net@6659#3contact@2539_metal-1-polysilicon-1 net@6659#3contact@2539_metal-1-polysilicon-1##0 5.425
R882 net@6659#3contact@2539_metal-1-polysilicon-1##0 net@6659#1pin@1409_polysilicon-1 5.425
R883 net@6639#10pmos@498_poly-right net@6639#11pin@1410_polysilicon-1 6.2
R884 net@6639#11pin@1410_polysilicon-1 net@6639#11pin@1410_polysilicon-1##0 9.688
R885 net@6639#11pin@1410_polysilicon-1##0 net@6639#11pin@1410_polysilicon-1##1 9.688
R886 net@6639#11pin@1410_polysilicon-1##1 net@6639#11pin@1410_polysilicon-1##2 9.688
R887 net@6639#11pin@1410_polysilicon-1##2 net@6639#11pin@1410_polysilicon-1##3 9.688
R888 net@6639#11pin@1410_polysilicon-1##3 net@6639#11pin@1410_polysilicon-1##4 9.688
R889 net@6639#11pin@1410_polysilicon-1##4 net@6639#11pin@1410_polysilicon-1##5 9.688
R890 net@6639#11pin@1410_polysilicon-1##5 net@6639#11pin@1410_polysilicon-1##6 9.688
R891 net@6639#11pin@1410_polysilicon-1##6 net@6639#11pin@1410_polysilicon-1##7 9.688
R892 net@6639#11pin@1410_polysilicon-1##7 net@6639#11pin@1410_polysilicon-1##8 9.688
R893 net@6639#11pin@1410_polysilicon-1##8 net@6639#11pin@1410_polysilicon-1##9 9.688
R894 net@6639#11pin@1410_polysilicon-1##9 net@6639#11pin@1410_polysilicon-1##10 9.688
R895 net@6639#11pin@1410_polysilicon-1##10 net@6639#11pin@1410_polysilicon-1##11 9.688
R896 net@6639#11pin@1410_polysilicon-1##11 net@6639#11pin@1410_polysilicon-1##12 9.688
R897 net@6639#11pin@1410_polysilicon-1##12 net@6639#11pin@1410_polysilicon-1##13 9.688
R898 net@6639#11pin@1410_polysilicon-1##13 net@6639#11pin@1410_polysilicon-1##14 9.688
R899 net@6639#11pin@1410_polysilicon-1##14 net@6639#11pin@1410_polysilicon-1##15 9.688
R900 net@6639#11pin@1410_polysilicon-1##15 net@6639#11pin@1410_polysilicon-1##16 9.688
R901 net@6639#11pin@1410_polysilicon-1##16 net@6639#11pin@1410_polysilicon-1##17 9.688
R902 net@6639#11pin@1410_polysilicon-1##17 net@6639#11pin@1410_polysilicon-1##18 9.688
R903 net@6639#11pin@1410_polysilicon-1##18 net@6639#11pin@1410_polysilicon-1##19 9.688
R904 net@6639#11pin@1410_polysilicon-1##19 net@6639#11pin@1410_polysilicon-1##20 9.688
R905 net@6639#11pin@1410_polysilicon-1##20 net@6639#11pin@1410_polysilicon-1##21 9.688
R906 net@6639#11pin@1410_polysilicon-1##21 net@6639#11pin@1410_polysilicon-1##22 9.688
R907 net@6639#11pin@1410_polysilicon-1##22 net@6639#12nmos@498_poly-right 9.688
R908 net@6639 net@6639##0 8.68
R909 net@6639##0 net@6639##1 8.68
R910 net@6639##1 net@6639##2 8.68
R911 net@6639##2 net@6639##3 8.68
R912 net@6639##3 net@6639#11pin@1410_polysilicon-1 8.68
R913 net@6668 net@6668 0
R914 net@6609#11pmos@484_poly-right net@6609#11pmos@484_poly-right##0 9.743
R915 net@6609#11pmos@484_poly-right##0 net@6609#11pmos@484_poly-right##1 9.743
R916 net@6609#11pmos@484_poly-right##1 net@6609#11pmos@484_poly-right##2 9.743
R917 net@6609#11pmos@484_poly-right##2 net@6609#11pmos@484_poly-right##3 9.743
R918 net@6609#11pmos@484_poly-right##3 net@6609#11pmos@484_poly-right##4 9.743
R919 net@6609#11pmos@484_poly-right##4 net@6609#11pmos@484_poly-right##5 9.743
R920 net@6609#11pmos@484_poly-right##5 net@6609#11pmos@484_poly-right##6 9.743
R921 net@6609#11pmos@484_poly-right##6 net@6609#11pmos@484_poly-right##7 9.743
R922 net@6609#11pmos@484_poly-right##7 net@6609#11pmos@484_poly-right##8 9.743
R923 net@6609#11pmos@484_poly-right##8 net@6609#11pmos@484_poly-right##9 9.743
R924 net@6609#11pmos@484_poly-right##9 net@6609#11pmos@484_poly-right##10 9.743
R925 net@6609#11pmos@484_poly-right##10 net@6609#11pmos@484_poly-right##11 9.743
R926 net@6609#11pmos@484_poly-right##11 net@6609#11pmos@484_poly-right##12 9.743
R927 net@6609#11pmos@484_poly-right##12 net@6609#11pmos@484_poly-right##13 9.743
R928 net@6609#11pmos@484_poly-right##13 net@6609#11pmos@484_poly-right##14 9.743
R929 net@6609#11pmos@484_poly-right##14 net@6609#11pmos@484_poly-right##15 9.743
R930 net@6609#11pmos@484_poly-right##15 net@6609#11pmos@484_poly-right##16 9.743
R931 net@6609#11pmos@484_poly-right##16 net@6609#11pmos@484_poly-right##17 9.743
R932 net@6609#11pmos@484_poly-right##17 net@6609#11pmos@484_poly-right##18 9.743
R933 net@6609#11pmos@484_poly-right##18 net@6609#11pmos@484_poly-right##19 9.743
R934 net@6609#11pmos@484_poly-right##19 net@6609#12pin@1381_polysilicon-1 9.743
R935 net@6609#12pin@1381_polysilicon-1 net@6609#12pin@1381_polysilicon-1##0 8.525
R936 net@6609#12pin@1381_polysilicon-1##0 net@6609#12pin@1381_polysilicon-1##1 8.525
R937 net@6609#12pin@1381_polysilicon-1##1 net@6609#12pin@1381_polysilicon-1##2 8.525
R938 net@6609#12pin@1381_polysilicon-1##2 net@6609#13nmos@485_poly-right 8.525
R939 net@6609 net@6609##0 9.042
R940 net@6609##0 net@6609##1 9.042
R941 net@6609##1 net@6609##2 9.042
R942 net@6609##2 net@6609##3 9.042
R943 net@6609##3 net@6609##4 9.042
R944 net@6609##4 net@6609#12pin@1381_polysilicon-1 9.042
R945 net@6694 net@6694##0 9.704
R946 net@6694##0 net@6694##1 9.704
R947 net@6694##1 net@6694##2 9.704
R948 net@6694##2 net@6694##3 9.704
R949 net@6694##3 net@6694##4 9.704
R950 net@6694##4 net@6694##5 9.704
R951 net@6694##5 net@6694##6 9.704
R952 net@6694##6 net@6694##7 9.704
R953 net@6694##7 net@6694##8 9.704
R954 net@6694##8 net@6694##9 9.704
R955 net@6694##9 net@6694##10 9.704
R956 net@6694##10 net@6694##11 9.704
R957 net@6694##11 net@6694##12 9.704
R958 net@6694##12 net@6694##13 9.704
R959 net@6694##13 net@6694##14 9.704
R960 net@6694##14 net@6694##15 9.704
R961 net@6694##15 net@6694##16 9.704
R962 net@6694##16 net@6694##17 9.704
R963 net@6694##17 net@6694##18 9.704
R964 net@6694##18 net@6694##19 9.704
R965 net@6694##19 net@6694##20 9.704
R966 net@6694##20 net@6694##21 9.704
R967 net@6694##21 net@6694#1pin@1383_polysilicon-1 9.704
R968 net@6694#1pin@1383_polysilicon-1 net@6694#1pin@1383_polysilicon-1##0 7.75
R969 net@6694#1pin@1383_polysilicon-1##0 net@6694#2pmos@485_poly-right 7.75
R970 net@6694#3contact@2477_metal-1-polysilicon-1 net@6694#3contact@2477_metal-1-polysilicon-1##0 9.3
R971 net@6694#3contact@2477_metal-1-polysilicon-1##0 net@6694#3contact@2477_metal-1-polysilicon-1##1 9.3
R972 net@6694#3contact@2477_metal-1-polysilicon-1##1 net@6694#3contact@2477_metal-1-polysilicon-1##2 9.3
R973 net@6694#3contact@2477_metal-1-polysilicon-1##2 net@6694#3contact@2477_metal-1-polysilicon-1##3 9.3
R974 net@6694#3contact@2477_metal-1-polysilicon-1##3 net@6694#1pin@1383_polysilicon-1 9.3
R975 net@6596#4pmos@483_poly-right net@6596#4pmos@483_poly-right##0 8.783
R976 net@6596#4pmos@483_poly-right##0 net@6596#4pmos@483_poly-right##1 8.783
R977 net@6596#4pmos@483_poly-right##1 net@6596#4pmos@483_poly-right##2 8.783
R978 net@6596#4pmos@483_poly-right##2 net@6596#4pmos@483_poly-right##3 8.783
R979 net@6596#4pmos@483_poly-right##3 net@6596#4pmos@483_poly-right##4 8.783
R980 net@6596#4pmos@483_poly-right##4 net@6596 8.783
R981 net@6596 net@6596##0 9.789
R982 net@6596##0 net@6596##1 9.789
R983 net@6596##1 net@6596##2 9.789
R984 net@6596##2 net@6596##3 9.789
R985 net@6596##3 net@6596##4 9.789
R986 net@6596##4 net@6596##5 9.789
R987 net@6596##5 net@6596##6 9.789
R988 net@6596##6 net@6596##7 9.789
R989 net@6596##7 net@6596##8 9.789
R990 net@6596##8 net@6596##9 9.789
R991 net@6596##9 net@6596##10 9.789
R992 net@6596##10 net@6596##11 9.789
R993 net@6596##11 net@6596##12 9.789
R994 net@6596##12 net@6596##13 9.789
R995 net@6596##13 net@6596##14 9.789
R996 net@6596##14 net@6596##15 9.789
R997 net@6596##15 net@6596##16 9.789
R998 net@6596##16 net@6596##17 9.789
R999 net@6596##17 net@6596#6nmos@484_poly-left 9.789
R1000 net@6632#4nmos@486_poly-left net@6632#4nmos@486_poly-left##0 9.756
R1001 net@6632#4nmos@486_poly-left##0 net@6632#4nmos@486_poly-left##1 9.756
R1002 net@6632#4nmos@486_poly-left##1 net@6632#4nmos@486_poly-left##2 9.756
R1003 net@6632#4nmos@486_poly-left##2 net@6632#4nmos@486_poly-left##3 9.756
R1004 net@6632#4nmos@486_poly-left##3 net@6632#4nmos@486_poly-left##4 9.756
R1005 net@6632#4nmos@486_poly-left##4 net@6632#4nmos@486_poly-left##5 9.756
R1006 net@6632#4nmos@486_poly-left##5 net@6632#4nmos@486_poly-left##6 9.756
R1007 net@6632#4nmos@486_poly-left##6 net@6632#4nmos@486_poly-left##7 9.756
R1008 net@6632#4nmos@486_poly-left##7 net@6632#4nmos@486_poly-left##8 9.756
R1009 net@6632#4nmos@486_poly-left##8 net@6632#4nmos@486_poly-left##9 9.756
R1010 net@6632#4nmos@486_poly-left##9 net@6632#4nmos@486_poly-left##10 9.756
R1011 net@6632#4nmos@486_poly-left##10 net@6632#4nmos@486_poly-left##11 9.756
R1012 net@6632#4nmos@486_poly-left##11 net@6632#4nmos@486_poly-left##12 9.756
R1013 net@6632#4nmos@486_poly-left##12 net@6632#4nmos@486_poly-left##13 9.756
R1014 net@6632#4nmos@486_poly-left##13 net@6632#4nmos@486_poly-left##14 9.756
R1015 net@6632#4nmos@486_poly-left##14 net@6632#4nmos@486_poly-left##15 9.756
R1016 net@6632#4nmos@486_poly-left##15 net@6632#5contact@2491_metal-1-polysilicon-1 9.756
R1017 net@6632#5contact@2491_metal-1-polysilicon-1 net@6632#5contact@2491_metal-1-polysilicon-1##0 9.106
R1018 net@6632#5contact@2491_metal-1-polysilicon-1##0 net@6632#5contact@2491_metal-1-polysilicon-1##1 9.106
R1019 net@6632#5contact@2491_metal-1-polysilicon-1##1 net@6632#5contact@2491_metal-1-polysilicon-1##2 9.106
R1020 net@6632#5contact@2491_metal-1-polysilicon-1##2 net@6632#5contact@2491_metal-1-polysilicon-1##3 9.106
R1021 net@6632#5contact@2491_metal-1-polysilicon-1##3 net@6632#5contact@2491_metal-1-polysilicon-1##4 9.106
R1022 net@6632#5contact@2491_metal-1-polysilicon-1##4 net@6632#5contact@2491_metal-1-polysilicon-1##5 9.106
R1023 net@6632#5contact@2491_metal-1-polysilicon-1##5 net@6632#5contact@2491_metal-1-polysilicon-1##6 9.106
R1024 net@6632#5contact@2491_metal-1-polysilicon-1##6 net@6632#6pmos@487_poly-right 9.106
R1025 net@6703 net@6703##0 9.574
R1026 net@6703##0 net@6703##1 9.574
R1027 net@6703##1 net@6703##2 9.574
R1028 net@6703##2 net@6703##3 9.574
R1029 net@6703##3 net@6703##4 9.574
R1030 net@6703##4 net@6703##5 9.574
R1031 net@6703##5 net@6703##6 9.574
R1032 net@6703##6 net@6703##7 9.574
R1033 net@6703##7 net@6703##8 9.574
R1034 net@6703##8 net@6703##9 9.574
R1035 net@6703##9 net@6703##10 9.574
R1036 net@6703##10 net@6703##11 9.574
R1037 net@6703##11 net@6703##12 9.574
R1038 net@6703##12 net@6703##13 9.574
R1039 net@6703##13 net@6703##14 9.574
R1040 net@6703##14 net@6703##15 9.574
R1041 net@6703##15 net@6703#1contact@2492_metal-1-polysilicon-1 9.574
R1042 net@6703#1contact@2492_metal-1-polysilicon-1 net@6703#1contact@2492_metal-1-polysilicon-1##0 9.494
R1043 net@6703#1contact@2492_metal-1-polysilicon-1##0 net@6703#1contact@2492_metal-1-polysilicon-1##1 9.494
R1044 net@6703#1contact@2492_metal-1-polysilicon-1##1 net@6703#1contact@2492_metal-1-polysilicon-1##2 9.494
R1045 net@6703#1contact@2492_metal-1-polysilicon-1##2 net@6703#1contact@2492_metal-1-polysilicon-1##3 9.494
R1046 net@6703#1contact@2492_metal-1-polysilicon-1##3 net@6703#1contact@2492_metal-1-polysilicon-1##4 9.494
R1047 net@6703#1contact@2492_metal-1-polysilicon-1##4 net@6703#1contact@2492_metal-1-polysilicon-1##5 9.494
R1048 net@6703#1contact@2492_metal-1-polysilicon-1##5 net@6703#1contact@2492_metal-1-polysilicon-1##6 9.494
R1049 net@6703#1contact@2492_metal-1-polysilicon-1##6 net@6703#2nmos@487_poly-left 9.494
R1050 net@6694#3contact@2477_metal-1-polysilicon-1 net@6694#3contact@2477_metal-1-polysilicon-1 0
R1051 net@6719 net@6719#1pin@1417_polysilicon-1 7.75
R1052 net@6719#1pin@1417_polysilicon-1 net@6719#1pin@1417_polysilicon-1##0 9.623
R1053 net@6719#1pin@1417_polysilicon-1##0 net@6719#1pin@1417_polysilicon-1##1 9.623
R1054 net@6719#1pin@1417_polysilicon-1##1 net@6719#1pin@1417_polysilicon-1##2 9.623
R1055 net@6719#1pin@1417_polysilicon-1##2 net@6719#1pin@1417_polysilicon-1##3 9.623
R1056 net@6719#1pin@1417_polysilicon-1##3 net@6719#1pin@1417_polysilicon-1##4 9.623
R1057 net@6719#1pin@1417_polysilicon-1##4 net@6719#1pin@1417_polysilicon-1##5 9.623
R1058 net@6719#1pin@1417_polysilicon-1##5 net@6719#1pin@1417_polysilicon-1##6 9.623
R1059 net@6719#1pin@1417_polysilicon-1##6 net@6719#1pin@1417_polysilicon-1##7 9.623
R1060 net@6719#1pin@1417_polysilicon-1##7 net@6719#1pin@1417_polysilicon-1##8 9.623
R1061 net@6719#1pin@1417_polysilicon-1##8 net@6719#1pin@1417_polysilicon-1##9 9.623
R1062 net@6719#1pin@1417_polysilicon-1##9 net@6719#1pin@1417_polysilicon-1##10 9.623
R1063 net@6719#1pin@1417_polysilicon-1##10 net@6719#1pin@1417_polysilicon-1##11 9.623
R1064 net@6719#1pin@1417_polysilicon-1##11 net@6719#1pin@1417_polysilicon-1##12 9.623
R1065 net@6719#1pin@1417_polysilicon-1##12 net@6719#1pin@1417_polysilicon-1##13 9.623
R1066 net@6719#1pin@1417_polysilicon-1##13 net@6719#1pin@1417_polysilicon-1##14 9.623
R1067 net@6719#1pin@1417_polysilicon-1##14 net@6719#1pin@1417_polysilicon-1##15 9.623
R1068 net@6719#1pin@1417_polysilicon-1##15 net@6719#1pin@1417_polysilicon-1##16 9.623
R1069 net@6719#1pin@1417_polysilicon-1##16 net@6719#1pin@1417_polysilicon-1##17 9.623
R1070 net@6719#1pin@1417_polysilicon-1##17 net@6719#1pin@1417_polysilicon-1##18 9.623
R1071 net@6719#1pin@1417_polysilicon-1##18 net@6719#1pin@1417_polysilicon-1##19 9.623
R1072 net@6719#1pin@1417_polysilicon-1##19 net@6719#1pin@1417_polysilicon-1##20 9.623
R1073 net@6719#1pin@1417_polysilicon-1##20 net@6719#1pin@1417_polysilicon-1##21 9.623
R1074 net@6719#1pin@1417_polysilicon-1##21 net@6719#1pin@1417_polysilicon-1##22 9.623
R1075 net@6719#1pin@1417_polysilicon-1##22 net@6719#2nmos@502_poly-right 9.623
R1076 net@6719#3contact@2556_metal-1-polysilicon-1 net@6719#3contact@2556_metal-1-polysilicon-1##0 8.68
R1077 net@6719#3contact@2556_metal-1-polysilicon-1##0 net@6719#3contact@2556_metal-1-polysilicon-1##1 8.68
R1078 net@6719#3contact@2556_metal-1-polysilicon-1##1 net@6719#3contact@2556_metal-1-polysilicon-1##2 8.68
R1079 net@6719#3contact@2556_metal-1-polysilicon-1##2 net@6719#3contact@2556_metal-1-polysilicon-1##3 8.68
R1080 net@6719#3contact@2556_metal-1-polysilicon-1##3 net@6719#1pin@1417_polysilicon-1 8.68
R1081 net@6703#4contact@2548_metal-1-n-act net@6703#4contact@2548_metal-1-n-act 0
R1082 S1#21pmos@500_poly-right S1#21pmos@500_poly-right##0 9.482
R1083 S1#21pmos@500_poly-right##0 S1#21pmos@500_poly-right##1 9.482
R1084 S1#21pmos@500_poly-right##1 S1#21pmos@500_poly-right##2 9.482
R1085 S1#21pmos@500_poly-right##2 S1#21pmos@500_poly-right##3 9.482
R1086 S1#21pmos@500_poly-right##3 S1#21pmos@500_poly-right##4 9.482
R1087 S1#21pmos@500_poly-right##4 S1#21pmos@500_poly-right##5 9.482
R1088 S1#21pmos@500_poly-right##5 S1#21pmos@500_poly-right##6 9.482
R1089 S1#21pmos@500_poly-right##6 S1#21pmos@500_poly-right##7 9.482
R1090 S1#21pmos@500_poly-right##7 S1#21pmos@500_poly-right##8 9.482
R1091 S1#21pmos@500_poly-right##8 S1#21pmos@500_poly-right##9 9.482
R1092 S1#21pmos@500_poly-right##9 S1#21pmos@500_poly-right##10 9.482
R1093 S1#21pmos@500_poly-right##10 S1#21pmos@500_poly-right##11 9.482
R1094 S1#21pmos@500_poly-right##11 S1#21pmos@500_poly-right##12 9.482
R1095 S1#21pmos@500_poly-right##12 S1#21pmos@500_poly-right##13 9.482
R1096 S1#21pmos@500_poly-right##13 S1#21pmos@500_poly-right##14 9.482
R1097 S1#21pmos@500_poly-right##14 S1#21pmos@500_poly-right##15 9.482
R1098 S1#21pmos@500_poly-right##15 S1 9.482
R1099 S1 S1##0 9.688
R1100 S1##0 S1##1 9.688
R1101 S1##1 S1##2 9.688
R1102 S1##2 S1##3 9.688
R1103 S1##3 S1##4 9.688
R1104 S1##4 S1##5 9.688
R1105 S1##5 S1##6 9.688
R1106 S1##6 S1#23nmos@501_poly-left 9.688
R1107 S0#23pmos@503_poly-right S0#23pmos@503_poly-right##0 9.871
R1108 S0#23pmos@503_poly-right##0 S0#23pmos@503_poly-right##1 9.871
R1109 S0#23pmos@503_poly-right##1 S0#23pmos@503_poly-right##2 9.871
R1110 S0#23pmos@503_poly-right##2 S0#23pmos@503_poly-right##3 9.871
R1111 S0#23pmos@503_poly-right##3 S0#23pmos@503_poly-right##4 9.871
R1112 S0#23pmos@503_poly-right##4 S0#23pmos@503_poly-right##5 9.871
R1113 S0#23pmos@503_poly-right##5 S0#23pmos@503_poly-right##6 9.871
R1114 S0#23pmos@503_poly-right##6 S0#23pmos@503_poly-right##7 9.871
R1115 S0#23pmos@503_poly-right##7 S0#23pmos@503_poly-right##8 9.871
R1116 S0#23pmos@503_poly-right##8 S0#23pmos@503_poly-right##9 9.871
R1117 S0#23pmos@503_poly-right##9 S0#23pmos@503_poly-right##10 9.871
R1118 S0#23pmos@503_poly-right##10 S0#23pmos@503_poly-right##11 9.871
R1119 S0#23pmos@503_poly-right##11 S0#23pmos@503_poly-right##12 9.871
R1120 S0#23pmos@503_poly-right##12 S0#23pmos@503_poly-right##13 9.871
R1121 S0#23pmos@503_poly-right##13 S0#23pmos@503_poly-right##14 9.871
R1122 S0#23pmos@503_poly-right##14 S0#23pmos@503_poly-right##15 9.871
R1123 S0#23pmos@503_poly-right##15 S0#23pmos@503_poly-right##16 9.871
R1124 S0#23pmos@503_poly-right##16 S0#23pmos@503_poly-right##17 9.871
R1125 S0#23pmos@503_poly-right##17 S0#24pin@1416_polysilicon-1 9.871
R1126 S0#24pin@1416_polysilicon-1 S0#24pin@1416_polysilicon-1##0 8.525
R1127 S0#24pin@1416_polysilicon-1##0 S0#24pin@1416_polysilicon-1##1 8.525
R1128 S0#24pin@1416_polysilicon-1##1 S0#24pin@1416_polysilicon-1##2 8.525
R1129 S0#24pin@1416_polysilicon-1##2 S0#24pin@1416_polysilicon-1##3 8.525
R1130 S0#24pin@1416_polysilicon-1##3 S0#24pin@1416_polysilicon-1##4 8.525
R1131 S0#24pin@1416_polysilicon-1##4 S0#25nmos@503_poly-left 8.525
R1132 S0 S0##0 5.425
R1133 S0##0 S0#24pin@1416_polysilicon-1 5.425
R1134 net@6614#3contact@2558_metal-1-p-act net@6614#3contact@2558_metal-1-p-act 0
R1135 S0#28pmos@505_poly-right S0#28pmos@505_poly-right##0 9.817
R1136 S0#28pmos@505_poly-right##0 S0#28pmos@505_poly-right##1 9.817
R1137 S0#28pmos@505_poly-right##1 S0#28pmos@505_poly-right##2 9.817
R1138 S0#28pmos@505_poly-right##2 S0#28pmos@505_poly-right##3 9.817
R1139 S0#28pmos@505_poly-right##3 S0#28pmos@505_poly-right##4 9.817
R1140 S0#28pmos@505_poly-right##4 S0#28pmos@505_poly-right##5 9.817
R1141 S0#28pmos@505_poly-right##5 S0#28pmos@505_poly-right##6 9.817
R1142 S0#28pmos@505_poly-right##6 S0#28pmos@505_poly-right##7 9.817
R1143 S0#28pmos@505_poly-right##7 S0#28pmos@505_poly-right##8 9.817
R1144 S0#28pmos@505_poly-right##8 S0#28pmos@505_poly-right##9 9.817
R1145 S0#28pmos@505_poly-right##9 S0#28pmos@505_poly-right##10 9.817
R1146 S0#28pmos@505_poly-right##10 S0#28pmos@505_poly-right##11 9.817
R1147 S0#28pmos@505_poly-right##11 S0#28pmos@505_poly-right##12 9.817
R1148 S0#28pmos@505_poly-right##12 S0#28pmos@505_poly-right##13 9.817
R1149 S0#28pmos@505_poly-right##13 S0#28pmos@505_poly-right##14 9.817
R1150 S0#28pmos@505_poly-right##14 S0#28pmos@505_poly-right##15 9.817
R1151 S0#28pmos@505_poly-right##15 S0#28pmos@505_poly-right##16 9.817
R1152 S0#28pmos@505_poly-right##16 S0#28pmos@505_poly-right##17 9.817
R1153 S0#28pmos@505_poly-right##17 S0#28pmos@505_poly-right##18 9.817
R1154 S0#28pmos@505_poly-right##18 S0#28pmos@505_poly-right##19 9.817
R1155 S0#28pmos@505_poly-right##19 S0#29pin@1418_polysilicon-1 9.817
R1156 S0#29pin@1418_polysilicon-1 S0#29pin@1418_polysilicon-1##0 8.138
R1157 S0#29pin@1418_polysilicon-1##0 S0#29pin@1418_polysilicon-1##1 8.138
R1158 S0#29pin@1418_polysilicon-1##1 S0#29pin@1418_polysilicon-1##2 8.138
R1159 S0#29pin@1418_polysilicon-1##2 S0#30nmos@505_poly-right 8.138
R1160 S0 S0##0 9.507
R1161 S0##0 S0##1 9.507
R1162 S0##1 S0##2 9.507
R1163 S0##2 S0##3 9.507
R1164 S0##3 S0##4 9.507
R1165 S0##4 S0##5 9.507
R1166 S0##5 S0##6 9.507
R1167 S0##6 S0##7 9.507
R1168 S0##7 S0##8 9.507
R1169 S0##8 S0##9 9.507
R1170 S0##9 S0##10 9.507
R1171 S0##10 S0##11 9.507
R1172 S0##11 S0##12 9.507
R1173 S0##12 S0##13 9.507
R1174 S0##13 S0#29pin@1418_polysilicon-1 9.507
R1175 net@6659#3contact@2539_metal-1-polysilicon-1 net@6659#3contact@2539_metal-1-polysilicon-1 0
R1176 S1#28pmos@504_poly-right S1#28pmos@504_poly-right##0 9.623
R1177 S1#28pmos@504_poly-right##0 S1#28pmos@504_poly-right##1 9.623
R1178 S1#28pmos@504_poly-right##1 S1#28pmos@504_poly-right##2 9.623
R1179 S1#28pmos@504_poly-right##2 S1#28pmos@504_poly-right##3 9.623
R1180 S1#28pmos@504_poly-right##3 S1#28pmos@504_poly-right##4 9.623
R1181 S1#28pmos@504_poly-right##4 S1#28pmos@504_poly-right##5 9.623
R1182 S1#28pmos@504_poly-right##5 S1#28pmos@504_poly-right##6 9.623
R1183 S1#28pmos@504_poly-right##6 S1#28pmos@504_poly-right##7 9.623
R1184 S1#28pmos@504_poly-right##7 S1#28pmos@504_poly-right##8 9.623
R1185 S1#28pmos@504_poly-right##8 S1#28pmos@504_poly-right##9 9.623
R1186 S1#28pmos@504_poly-right##9 S1#28pmos@504_poly-right##10 9.623
R1187 S1#28pmos@504_poly-right##10 S1#28pmos@504_poly-right##11 9.623
R1188 S1#28pmos@504_poly-right##11 S1#28pmos@504_poly-right##12 9.623
R1189 S1#28pmos@504_poly-right##12 S1#28pmos@504_poly-right##13 9.623
R1190 S1#28pmos@504_poly-right##13 S1#28pmos@504_poly-right##14 9.623
R1191 S1#28pmos@504_poly-right##14 S1#28pmos@504_poly-right##15 9.623
R1192 S1#28pmos@504_poly-right##15 S1#28pmos@504_poly-right##16 9.623
R1193 S1#28pmos@504_poly-right##16 S1#28pmos@504_poly-right##17 9.623
R1194 S1#28pmos@504_poly-right##17 S1#28pmos@504_poly-right##18 9.623
R1195 S1#28pmos@504_poly-right##18 S1#28pmos@504_poly-right##19 9.623
R1196 S1#28pmos@504_poly-right##19 S1#28pmos@504_poly-right##20 9.623
R1197 S1#28pmos@504_poly-right##20 S1#28pmos@504_poly-right##21 9.623
R1198 S1#28pmos@504_poly-right##21 S1#28pmos@504_poly-right##22 9.623
R1199 S1#28pmos@504_poly-right##22 S1#29pin@1419_polysilicon-1 9.623
R1200 S1#29pin@1419_polysilicon-1 S1#30nmos@504_poly-right 7.75
R1201 S1 S1##0 6.2
R1202 S1##0 S1#29pin@1419_polysilicon-1 6.2
R1203 D7#3nmos@500_poly-left D7#3nmos@500_poly-left##0 9.92
R1204 D7#3nmos@500_poly-left##0 D7#3nmos@500_poly-left##1 9.92
R1205 D7#3nmos@500_poly-left##1 D7#3nmos@500_poly-left##2 9.92
R1206 D7#3nmos@500_poly-left##2 D7#3nmos@500_poly-left##3 9.92
R1207 D7#3nmos@500_poly-left##3 D7#3nmos@500_poly-left##4 9.92
R1208 D7#3nmos@500_poly-left##4 D7#3nmos@500_poly-left##5 9.92
R1209 D7#3nmos@500_poly-left##5 D7#3nmos@500_poly-left##6 9.92
R1210 D7#3nmos@500_poly-left##6 D7#3nmos@500_poly-left##7 9.92
R1211 D7#3nmos@500_poly-left##7 D7#3nmos@500_poly-left##8 9.92
R1212 D7#3nmos@500_poly-left##8 D7#4pin@1420_polysilicon-1 9.92
R1213 D7#4pin@1420_polysilicon-1 D7#4pin@1420_polysilicon-1##0 9.964
R1214 D7#4pin@1420_polysilicon-1##0 D7#4pin@1420_polysilicon-1##1 9.964
R1215 D7#4pin@1420_polysilicon-1##1 D7#4pin@1420_polysilicon-1##2 9.964
R1216 D7#4pin@1420_polysilicon-1##2 D7#4pin@1420_polysilicon-1##3 9.964
R1217 D7#4pin@1420_polysilicon-1##3 D7#4pin@1420_polysilicon-1##4 9.964
R1218 D7#4pin@1420_polysilicon-1##4 D7#4pin@1420_polysilicon-1##5 9.964
R1219 D7#4pin@1420_polysilicon-1##5 D7#4pin@1420_polysilicon-1##6 9.964
R1220 D7#4pin@1420_polysilicon-1##6 D7#4pin@1420_polysilicon-1##7 9.964
R1221 D7#4pin@1420_polysilicon-1##7 D7#4pin@1420_polysilicon-1##8 9.964
R1222 D7#4pin@1420_polysilicon-1##8 D7#4pin@1420_polysilicon-1##9 9.964
R1223 D7#4pin@1420_polysilicon-1##9 D7#4pin@1420_polysilicon-1##10 9.964
R1224 D7#4pin@1420_polysilicon-1##10 D7#4pin@1420_polysilicon-1##11 9.964
R1225 D7#4pin@1420_polysilicon-1##11 D7#4pin@1420_polysilicon-1##12 9.964
R1226 D7#4pin@1420_polysilicon-1##12 D7#5pmos@501_poly-right 9.964
R1227 D7 D7##0 8.06
R1228 D7##0 D7##1 8.06
R1229 D7##1 D7##2 8.06
R1230 D7##2 D7##3 8.06
R1231 D7##3 D7#4pin@1420_polysilicon-1 8.06
R1232 D6 D6#3contact@2527_metal-1-polysilicon-1 4.576
R1233 net@6614#3contact@2558_metal-1-p-act net@6614#1contact@2521_metal-1-polysilicon-1 4.706
R1234 D5 D5#3contact@2511_metal-1-polysilicon-1 6.838
R1235 D4#0contact@2586_metal-1-metal-2 D4 9.087
R1236 net@6632 net@6632#5contact@2491_metal-1-polysilicon-1 5.07
R1237 S0#21contact@2523_metal-1-polysilicon-1 S0 4.68
R1238 net@6703#4contact@2548_metal-1-n-act net@6703#1contact@2492_metal-1-polysilicon-1 7.254
R1239 D4#3nmos@488_poly-left D4#3nmos@488_poly-left##0 9.723
R1240 D4#3nmos@488_poly-left##0 D4#3nmos@488_poly-left##1 9.723
R1241 D4#3nmos@488_poly-left##1 D4#3nmos@488_poly-left##2 9.723
R1242 D4#3nmos@488_poly-left##2 D4#3nmos@488_poly-left##3 9.723
R1243 D4#3nmos@488_poly-left##3 D4#3nmos@488_poly-left##4 9.723
R1244 D4#3nmos@488_poly-left##4 D4#3nmos@488_poly-left##5 9.723
R1245 D4#3nmos@488_poly-left##5 D4#3nmos@488_poly-left##6 9.723
R1246 D4#3nmos@488_poly-left##6 D4#3nmos@488_poly-left##7 9.723
R1247 D4#3nmos@488_poly-left##7 D4#3nmos@488_poly-left##8 9.723
R1248 D4#3nmos@488_poly-left##8 D4#3nmos@488_poly-left##9 9.723
R1249 D4#3nmos@488_poly-left##9 D4#3nmos@488_poly-left##10 9.723
R1250 D4#3nmos@488_poly-left##10 D4#3nmos@488_poly-left##11 9.723
R1251 D4#3nmos@488_poly-left##11 D4#3nmos@488_poly-left##12 9.723
R1252 D4#3nmos@488_poly-left##12 D4#3nmos@488_poly-left##13 9.723
R1253 D4#3nmos@488_poly-left##13 D4#3nmos@488_poly-left##14 9.723
R1254 D4#3nmos@488_poly-left##14 D4#3nmos@488_poly-left##15 9.723
R1255 D4#3nmos@488_poly-left##15 D4#3nmos@488_poly-left##16 9.723
R1256 D4#3nmos@488_poly-left##16 D4#3nmos@488_poly-left##17 9.723
R1257 D4#3nmos@488_poly-left##17 D4#3nmos@488_poly-left##18 9.723
R1258 D4#3nmos@488_poly-left##18 D4#3nmos@488_poly-left##19 9.723
R1259 D4#3nmos@488_poly-left##19 D4#3nmos@488_poly-left##20 9.723
R1260 D4#3nmos@488_poly-left##20 D4#4pin@1387_polysilicon-1 9.723
R1261 D4#4pin@1387_polysilicon-1 D4#4pin@1387_polysilicon-1##0 8.267
R1262 D4#4pin@1387_polysilicon-1##0 D4#4pin@1387_polysilicon-1##1 8.267
R1263 D4#4pin@1387_polysilicon-1##1 D4#5pmos@489_poly-right 8.267
R1264 D4#0contact@2586_metal-1-metal-2 D4#0contact@2586_metal-1-metal-2##0 8.138
R1265 D4#0contact@2586_metal-1-metal-2##0 D4#0contact@2586_metal-1-metal-2##1 8.138
R1266 D4#0contact@2586_metal-1-metal-2##1 D4#0contact@2586_metal-1-metal-2##2 8.138
R1267 D4#0contact@2586_metal-1-metal-2##2 D4#4pin@1387_polysilicon-1 8.138
R1268 net@6659#16pmos@488_poly-right net@6659#16pmos@488_poly-right##0 9.817
R1269 net@6659#16pmos@488_poly-right##0 net@6659#16pmos@488_poly-right##1 9.817
R1270 net@6659#16pmos@488_poly-right##1 net@6659#16pmos@488_poly-right##2 9.817
R1271 net@6659#16pmos@488_poly-right##2 net@6659#16pmos@488_poly-right##3 9.817
R1272 net@6659#16pmos@488_poly-right##3 net@6659#16pmos@488_poly-right##4 9.817
R1273 net@6659#16pmos@488_poly-right##4 net@6659#16pmos@488_poly-right##5 9.817
R1274 net@6659#16pmos@488_poly-right##5 net@6659#16pmos@488_poly-right##6 9.817
R1275 net@6659#16pmos@488_poly-right##6 net@6659#16pmos@488_poly-right##7 9.817
R1276 net@6659#16pmos@488_poly-right##7 net@6659#16pmos@488_poly-right##8 9.817
R1277 net@6659#16pmos@488_poly-right##8 net@6659#16pmos@488_poly-right##9 9.817
R1278 net@6659#16pmos@488_poly-right##9 net@6659#16pmos@488_poly-right##10 9.817
R1279 net@6659#16pmos@488_poly-right##10 net@6659#3contact@2539_metal-1-polysilicon-1 9.817
R1280 net@6659#3contact@2539_metal-1-polysilicon-1 net@6659#3contact@2539_metal-1-polysilicon-1##0 9.3
R1281 net@6659#3contact@2539_metal-1-polysilicon-1##0 net@6659#3contact@2539_metal-1-polysilicon-1##1 9.3
R1282 net@6659#3contact@2539_metal-1-polysilicon-1##1 net@6659#3contact@2539_metal-1-polysilicon-1##2 9.3
R1283 net@6659#3contact@2539_metal-1-polysilicon-1##2 net@6659#3contact@2539_metal-1-polysilicon-1##3 9.3
R1284 net@6659#3contact@2539_metal-1-polysilicon-1##3 net@6659#3contact@2539_metal-1-polysilicon-1##4 9.3
R1285 net@6659#3contact@2539_metal-1-polysilicon-1##4 net@6659#3contact@2539_metal-1-polysilicon-1##5 9.3
R1286 net@6659#3contact@2539_metal-1-polysilicon-1##5 net@6659#3contact@2539_metal-1-polysilicon-1##6 9.3
R1287 net@6659#3contact@2539_metal-1-polysilicon-1##6 net@6659#3contact@2539_metal-1-polysilicon-1##7 9.3
R1288 net@6659#3contact@2539_metal-1-polysilicon-1##7 net@6659#3contact@2539_metal-1-polysilicon-1##8 9.3
R1289 net@6659#3contact@2539_metal-1-polysilicon-1##8 net@6659#3contact@2539_metal-1-polysilicon-1##9 9.3
R1290 net@6659#3contact@2539_metal-1-polysilicon-1##9 net@6659#3contact@2539_metal-1-polysilicon-1##10 9.3
R1291 net@6659#3contact@2539_metal-1-polysilicon-1##10 net@6659#3contact@2539_metal-1-polysilicon-1##11 9.3
R1292 net@6659#3contact@2539_metal-1-polysilicon-1##11 net@6659#18nmos@489_poly-left 9.3
R1293 net@6614#13pmos@491_poly-right net@6614#13pmos@491_poly-right##0 9.403
R1294 net@6614#13pmos@491_poly-right##0 net@6614#13pmos@491_poly-right##1 9.403
R1295 net@6614#13pmos@491_poly-right##1 net@6614#13pmos@491_poly-right##2 9.403
R1296 net@6614#13pmos@491_poly-right##2 net@6614#13pmos@491_poly-right##3 9.403
R1297 net@6614#13pmos@491_poly-right##3 net@6614#13pmos@491_poly-right##4 9.403
R1298 net@6614#13pmos@491_poly-right##4 net@6614#13pmos@491_poly-right##5 9.403
R1299 net@6614#13pmos@491_poly-right##5 net@6614#13pmos@491_poly-right##6 9.403
R1300 net@6614#13pmos@491_poly-right##6 net@6614#13pmos@491_poly-right##7 9.403
R1301 net@6614#13pmos@491_poly-right##7 net@6614#13pmos@491_poly-right##8 9.403
R1302 net@6614#13pmos@491_poly-right##8 net@6614#13pmos@491_poly-right##9 9.403
R1303 net@6614#13pmos@491_poly-right##9 net@6614#13pmos@491_poly-right##10 9.403
R1304 net@6614#13pmos@491_poly-right##10 net@6614#13pmos@491_poly-right##11 9.403
R1305 net@6614#13pmos@491_poly-right##11 net@6614#13pmos@491_poly-right##12 9.403
R1306 net@6614#13pmos@491_poly-right##12 net@6614#13pmos@491_poly-right##13 9.403
R1307 net@6614#13pmos@491_poly-right##13 net@6614#14pin@1393_polysilicon-1 9.403
R1308 net@6614#14pin@1393_polysilicon-1 net@6614#14pin@1393_polysilicon-1##0 9.765
R1309 net@6614#14pin@1393_polysilicon-1##0 net@6614#14pin@1393_polysilicon-1##1 9.765
R1310 net@6614#14pin@1393_polysilicon-1##1 net@6614#14pin@1393_polysilicon-1##2 9.765
R1311 net@6614#14pin@1393_polysilicon-1##2 net@6614#14pin@1393_polysilicon-1##3 9.765
R1312 net@6614#14pin@1393_polysilicon-1##3 net@6614#14pin@1393_polysilicon-1##4 9.765
R1313 net@6614#14pin@1393_polysilicon-1##4 net@6614#14pin@1393_polysilicon-1##5 9.765
R1314 net@6614#14pin@1393_polysilicon-1##5 net@6614#14pin@1393_polysilicon-1##6 9.765
R1315 net@6614#14pin@1393_polysilicon-1##6 net@6614#14pin@1393_polysilicon-1##7 9.765
R1316 net@6614#14pin@1393_polysilicon-1##7 net@6614#14pin@1393_polysilicon-1##8 9.765
R1317 net@6614#14pin@1393_polysilicon-1##8 net@6614#15nmos@491_poly-left 9.765
R1318 net@6614#1contact@2521_metal-1-polysilicon-1 net@6614#1contact@2521_metal-1-polysilicon-1##0 5.425
R1319 net@6614#1contact@2521_metal-1-polysilicon-1##0 net@6614#14pin@1393_polysilicon-1 5.425
R1320 net@6891 net@6891#1pin@1459_polysilicon-1 7.75
R1321 net@6891#1pin@1459_polysilicon-1 net@6891#1pin@1459_polysilicon-1##0 9.623
R1322 net@6891#1pin@1459_polysilicon-1##0 net@6891#1pin@1459_polysilicon-1##1 9.623
R1323 net@6891#1pin@1459_polysilicon-1##1 net@6891#1pin@1459_polysilicon-1##2 9.623
R1324 net@6891#1pin@1459_polysilicon-1##2 net@6891#1pin@1459_polysilicon-1##3 9.623
R1325 net@6891#1pin@1459_polysilicon-1##3 net@6891#1pin@1459_polysilicon-1##4 9.623
R1326 net@6891#1pin@1459_polysilicon-1##4 net@6891#1pin@1459_polysilicon-1##5 9.623
R1327 net@6891#1pin@1459_polysilicon-1##5 net@6891#1pin@1459_polysilicon-1##6 9.623
R1328 net@6891#1pin@1459_polysilicon-1##6 net@6891#1pin@1459_polysilicon-1##7 9.623
R1329 net@6891#1pin@1459_polysilicon-1##7 net@6891#1pin@1459_polysilicon-1##8 9.623
R1330 net@6891#1pin@1459_polysilicon-1##8 net@6891#1pin@1459_polysilicon-1##9 9.623
R1331 net@6891#1pin@1459_polysilicon-1##9 net@6891#1pin@1459_polysilicon-1##10 9.623
R1332 net@6891#1pin@1459_polysilicon-1##10 net@6891#1pin@1459_polysilicon-1##11 9.623
R1333 net@6891#1pin@1459_polysilicon-1##11 net@6891#1pin@1459_polysilicon-1##12 9.623
R1334 net@6891#1pin@1459_polysilicon-1##12 net@6891#1pin@1459_polysilicon-1##13 9.623
R1335 net@6891#1pin@1459_polysilicon-1##13 net@6891#1pin@1459_polysilicon-1##14 9.623
R1336 net@6891#1pin@1459_polysilicon-1##14 net@6891#1pin@1459_polysilicon-1##15 9.623
R1337 net@6891#1pin@1459_polysilicon-1##15 net@6891#1pin@1459_polysilicon-1##16 9.623
R1338 net@6891#1pin@1459_polysilicon-1##16 net@6891#1pin@1459_polysilicon-1##17 9.623
R1339 net@6891#1pin@1459_polysilicon-1##17 net@6891#1pin@1459_polysilicon-1##18 9.623
R1340 net@6891#1pin@1459_polysilicon-1##18 net@6891#1pin@1459_polysilicon-1##19 9.623
R1341 net@6891#1pin@1459_polysilicon-1##19 net@6891#1pin@1459_polysilicon-1##20 9.623
R1342 net@6891#1pin@1459_polysilicon-1##20 net@6891#1pin@1459_polysilicon-1##21 9.623
R1343 net@6891#1pin@1459_polysilicon-1##21 net@6891#1pin@1459_polysilicon-1##22 9.623
R1344 net@6891#1pin@1459_polysilicon-1##22 net@6891#2nmos@513_poly-right 9.623
R1345 net@6891#3contact@2626_metal-1-polysilicon-1 net@6891#3contact@2626_metal-1-polysilicon-1##0 8.68
R1346 net@6891#3contact@2626_metal-1-polysilicon-1##0 net@6891#3contact@2626_metal-1-polysilicon-1##1 8.68
R1347 net@6891#3contact@2626_metal-1-polysilicon-1##1 net@6891#3contact@2626_metal-1-polysilicon-1##2 8.68
R1348 net@6891#3contact@2626_metal-1-polysilicon-1##2 net@6891#3contact@2626_metal-1-polysilicon-1##3 8.68
R1349 net@6891#3contact@2626_metal-1-polysilicon-1##3 net@6891#1pin@1459_polysilicon-1 8.68
R1350 net@6895 net@6895 0
R1351 D9#0nmos@515_poly-left D9#0nmos@515_poly-left##0 9.953
R1352 D9#0nmos@515_poly-left##0 D9#0nmos@515_poly-left##1 9.953
R1353 D9#0nmos@515_poly-left##1 D9#0nmos@515_poly-left##2 9.953
R1354 D9#0nmos@515_poly-left##2 D9#0nmos@515_poly-left##3 9.953
R1355 D9#0nmos@515_poly-left##3 D9#0nmos@515_poly-left##4 9.953
R1356 D9#0nmos@515_poly-left##4 D9#0nmos@515_poly-left##5 9.953
R1357 D9#0nmos@515_poly-left##5 D9#0nmos@515_poly-left##6 9.953
R1358 D9#0nmos@515_poly-left##6 D9#0nmos@515_poly-left##7 9.953
R1359 D9#0nmos@515_poly-left##7 D9#0nmos@515_poly-left##8 9.953
R1360 D9#0nmos@515_poly-left##8 D9#0nmos@515_poly-left##9 9.953
R1361 D9#0nmos@515_poly-left##9 D9#0nmos@515_poly-left##10 9.953
R1362 D9#0nmos@515_poly-left##10 D9#0nmos@515_poly-left##11 9.953
R1363 D9#0nmos@515_poly-left##11 D9#0nmos@515_poly-left##12 9.953
R1364 D9#0nmos@515_poly-left##12 D9#0nmos@515_poly-left##13 9.953
R1365 D9#0nmos@515_poly-left##13 D9#0nmos@515_poly-left##14 9.953
R1366 D9#0nmos@515_poly-left##14 D9#0nmos@515_poly-left##15 9.953
R1367 D9#0nmos@515_poly-left##15 D9#0nmos@515_poly-left##16 9.953
R1368 D9#0nmos@515_poly-left##16 D9#0nmos@515_poly-left##17 9.953
R1369 D9#0nmos@515_poly-left##17 D9#1pin@1460_polysilicon-1 9.953
R1370 D9#1pin@1460_polysilicon-1 D9#1pin@1460_polysilicon-1##0 9.92
R1371 D9#1pin@1460_polysilicon-1##0 D9#1pin@1460_polysilicon-1##1 9.92
R1372 D9#1pin@1460_polysilicon-1##1 D9#1pin@1460_polysilicon-1##2 9.92
R1373 D9#1pin@1460_polysilicon-1##2 D9#1pin@1460_polysilicon-1##3 9.92
R1374 D9#1pin@1460_polysilicon-1##3 D9#2pmos@516_poly-right 9.92
R1375 D9#3contact@2629_metal-1-polysilicon-1 D9#3contact@2629_metal-1-polysilicon-1##0 8.525
R1376 D9#3contact@2629_metal-1-polysilicon-1##0 D9#3contact@2629_metal-1-polysilicon-1##1 8.525
R1377 D9#3contact@2629_metal-1-polysilicon-1##1 D9#3contact@2629_metal-1-polysilicon-1##2 8.525
R1378 D9#3contact@2629_metal-1-polysilicon-1##2 D9#1pin@1460_polysilicon-1 8.525
R1379 net@6913 net@6913##0 9.545
R1380 net@6913##0 net@6913##1 9.545
R1381 net@6913##1 net@6913##2 9.545
R1382 net@6913##2 net@6913##3 9.545
R1383 net@6913##3 net@6913##4 9.545
R1384 net@6913##4 net@6913##5 9.545
R1385 net@6913##5 net@6913##6 9.545
R1386 net@6913##6 net@6913##7 9.545
R1387 net@6913##7 net@6913##8 9.545
R1388 net@6913##8 net@6913##9 9.545
R1389 net@6913##9 net@6913##10 9.545
R1390 net@6913##10 net@6913##11 9.545
R1391 net@6913##11 net@6913##12 9.545
R1392 net@6913##12 net@6913##13 9.545
R1393 net@6913##13 net@6913##14 9.545
R1394 net@6913##14 net@6913##15 9.545
R1395 net@6913##15 net@6913##16 9.545
R1396 net@6913##16 net@6913##17 9.545
R1397 net@6913##17 net@6913#1contact@2639_metal-1-polysilicon-1 9.545
R1398 net@6913#1contact@2639_metal-1-polysilicon-1 net@6913#1contact@2639_metal-1-polysilicon-1##0 9.558
R1399 net@6913#1contact@2639_metal-1-polysilicon-1##0 net@6913#1contact@2639_metal-1-polysilicon-1##1 9.558
R1400 net@6913#1contact@2639_metal-1-polysilicon-1##1 net@6913#1contact@2639_metal-1-polysilicon-1##2 9.558
R1401 net@6913#1contact@2639_metal-1-polysilicon-1##2 net@6913#1contact@2639_metal-1-polysilicon-1##3 9.558
R1402 net@6913#1contact@2639_metal-1-polysilicon-1##3 net@6913#1contact@2639_metal-1-polysilicon-1##4 9.558
R1403 net@6913#1contact@2639_metal-1-polysilicon-1##4 net@6913#2nmos@516_poly-left 9.558
R1404 S0#36pmos@518_poly-right S0#36pmos@518_poly-right##0 9.743
R1405 S0#36pmos@518_poly-right##0 S0#36pmos@518_poly-right##1 9.743
R1406 S0#36pmos@518_poly-right##1 S0#36pmos@518_poly-right##2 9.743
R1407 S0#36pmos@518_poly-right##2 S0#36pmos@518_poly-right##3 9.743
R1408 S0#36pmos@518_poly-right##3 S0#36pmos@518_poly-right##4 9.743
R1409 S0#36pmos@518_poly-right##4 S0#36pmos@518_poly-right##5 9.743
R1410 S0#36pmos@518_poly-right##5 S0#36pmos@518_poly-right##6 9.743
R1411 S0#36pmos@518_poly-right##6 S0#36pmos@518_poly-right##7 9.743
R1412 S0#36pmos@518_poly-right##7 S0#36pmos@518_poly-right##8 9.743
R1413 S0#36pmos@518_poly-right##8 S0#36pmos@518_poly-right##9 9.743
R1414 S0#36pmos@518_poly-right##9 S0#36pmos@518_poly-right##10 9.743
R1415 S0#36pmos@518_poly-right##10 S0#36pmos@518_poly-right##11 9.743
R1416 S0#36pmos@518_poly-right##11 S0#36pmos@518_poly-right##12 9.743
R1417 S0#36pmos@518_poly-right##12 S0#36pmos@518_poly-right##13 9.743
R1418 S0#36pmos@518_poly-right##13 S0#36pmos@518_poly-right##14 9.743
R1419 S0#36pmos@518_poly-right##14 S0#36pmos@518_poly-right##15 9.743
R1420 S0#36pmos@518_poly-right##15 S0#36pmos@518_poly-right##16 9.743
R1421 S0#36pmos@518_poly-right##16 S0#36pmos@518_poly-right##17 9.743
R1422 S0#36pmos@518_poly-right##17 S0#36pmos@518_poly-right##18 9.743
R1423 S0#36pmos@518_poly-right##18 S0#36pmos@518_poly-right##19 9.743
R1424 S0#36pmos@518_poly-right##19 S0#37pin@1466_polysilicon-1 9.743
R1425 S0#37pin@1466_polysilicon-1 S0#37pin@1466_polysilicon-1##0 8.525
R1426 S0#37pin@1466_polysilicon-1##0 S0#37pin@1466_polysilicon-1##1 8.525
R1427 S0#37pin@1466_polysilicon-1##1 S0#37pin@1466_polysilicon-1##2 8.525
R1428 S0#37pin@1466_polysilicon-1##2 S0#38nmos@518_poly-left 8.525
R1429 S0#39contact@2641_metal-1-polysilicon-1 S0#39contact@2641_metal-1-polysilicon-1##0 5.425
R1430 S0#39contact@2641_metal-1-polysilicon-1##0 S0#37pin@1466_polysilicon-1 5.425
R1431 net@6902#10pmos@517_poly-right net@6902#11pin@1467_polysilicon-1 6.2
R1432 net@6902#11pin@1467_polysilicon-1 net@6902#11pin@1467_polysilicon-1##0 9.688
R1433 net@6902#11pin@1467_polysilicon-1##0 net@6902#11pin@1467_polysilicon-1##1 9.688
R1434 net@6902#11pin@1467_polysilicon-1##1 net@6902#11pin@1467_polysilicon-1##2 9.688
R1435 net@6902#11pin@1467_polysilicon-1##2 net@6902#11pin@1467_polysilicon-1##3 9.688
R1436 net@6902#11pin@1467_polysilicon-1##3 net@6902#11pin@1467_polysilicon-1##4 9.688
R1437 net@6902#11pin@1467_polysilicon-1##4 net@6902#11pin@1467_polysilicon-1##5 9.688
R1438 net@6902#11pin@1467_polysilicon-1##5 net@6902#11pin@1467_polysilicon-1##6 9.688
R1439 net@6902#11pin@1467_polysilicon-1##6 net@6902#11pin@1467_polysilicon-1##7 9.688
R1440 net@6902#11pin@1467_polysilicon-1##7 net@6902#11pin@1467_polysilicon-1##8 9.688
R1441 net@6902#11pin@1467_polysilicon-1##8 net@6902#11pin@1467_polysilicon-1##9 9.688
R1442 net@6902#11pin@1467_polysilicon-1##9 net@6902#11pin@1467_polysilicon-1##10 9.688
R1443 net@6902#11pin@1467_polysilicon-1##10 net@6902#11pin@1467_polysilicon-1##11 9.688
R1444 net@6902#11pin@1467_polysilicon-1##11 net@6902#11pin@1467_polysilicon-1##12 9.688
R1445 net@6902#11pin@1467_polysilicon-1##12 net@6902#11pin@1467_polysilicon-1##13 9.688
R1446 net@6902#11pin@1467_polysilicon-1##13 net@6902#11pin@1467_polysilicon-1##14 9.688
R1447 net@6902#11pin@1467_polysilicon-1##14 net@6902#11pin@1467_polysilicon-1##15 9.688
R1448 net@6902#11pin@1467_polysilicon-1##15 net@6902#11pin@1467_polysilicon-1##16 9.688
R1449 net@6902#11pin@1467_polysilicon-1##16 net@6902#11pin@1467_polysilicon-1##17 9.688
R1450 net@6902#11pin@1467_polysilicon-1##17 net@6902#11pin@1467_polysilicon-1##18 9.688
R1451 net@6902#11pin@1467_polysilicon-1##18 net@6902#11pin@1467_polysilicon-1##19 9.688
R1452 net@6902#11pin@1467_polysilicon-1##19 net@6902#11pin@1467_polysilicon-1##20 9.688
R1453 net@6902#11pin@1467_polysilicon-1##20 net@6902#11pin@1467_polysilicon-1##21 9.688
R1454 net@6902#11pin@1467_polysilicon-1##21 net@6902#11pin@1467_polysilicon-1##22 9.688
R1455 net@6902#11pin@1467_polysilicon-1##22 net@6902#12nmos@517_poly-right 9.688
R1456 net@6902 net@6902##0 8.68
R1457 net@6902##0 net@6902##1 8.68
R1458 net@6902##1 net@6902##2 8.68
R1459 net@6902##2 net@6902##3 8.68
R1460 net@6902##3 net@6902#11pin@1467_polysilicon-1 8.68
R1461 net@6931 net@6931 0
R1462 D10#0nmos@519_poly-left D10#0nmos@519_poly-left##0 9.665
R1463 D10#0nmos@519_poly-left##0 D10#0nmos@519_poly-left##1 9.665
R1464 D10#0nmos@519_poly-left##1 D10#0nmos@519_poly-left##2 9.665
R1465 D10#0nmos@519_poly-left##2 D10#0nmos@519_poly-left##3 9.665
R1466 D10#0nmos@519_poly-left##3 D10#0nmos@519_poly-left##4 9.665
R1467 D10#0nmos@519_poly-left##4 D10#0nmos@519_poly-left##5 9.665
R1468 D10#0nmos@519_poly-left##5 D10#0nmos@519_poly-left##6 9.665
R1469 D10#0nmos@519_poly-left##6 D10#0nmos@519_poly-left##7 9.665
R1470 D10#0nmos@519_poly-left##7 D10#0nmos@519_poly-left##8 9.665
R1471 D10#0nmos@519_poly-left##8 D10#0nmos@519_poly-left##9 9.665
R1472 D10#0nmos@519_poly-left##9 D10#0nmos@519_poly-left##10 9.665
R1473 D10#0nmos@519_poly-left##10 D10#0nmos@519_poly-left##11 9.665
R1474 D10#0nmos@519_poly-left##11 D10#0nmos@519_poly-left##12 9.665
R1475 D10#0nmos@519_poly-left##12 D10#0nmos@519_poly-left##13 9.665
R1476 D10#0nmos@519_poly-left##13 D10#0nmos@519_poly-left##14 9.665
R1477 D10#0nmos@519_poly-left##14 D10#0nmos@519_poly-left##15 9.665
R1478 D10#0nmos@519_poly-left##15 D10#1pin@1468_polysilicon-1 9.665
R1479 D10#1pin@1468_polysilicon-1 D10#1pin@1468_polysilicon-1##0 9.3
R1480 D10#1pin@1468_polysilicon-1##0 D10#1pin@1468_polysilicon-1##1 9.3
R1481 D10#1pin@1468_polysilicon-1##1 D10#1pin@1468_polysilicon-1##2 9.3
R1482 D10#1pin@1468_polysilicon-1##2 D10#1pin@1468_polysilicon-1##3 9.3
R1483 D10#1pin@1468_polysilicon-1##3 D10#1pin@1468_polysilicon-1##4 9.3
R1484 D10#1pin@1468_polysilicon-1##4 D10#1pin@1468_polysilicon-1##5 9.3
R1485 D10#1pin@1468_polysilicon-1##5 D10#1pin@1468_polysilicon-1##6 9.3
R1486 D10#1pin@1468_polysilicon-1##6 D10#2pmos@520_poly-right 9.3
R1487 D10#3contact@2645_metal-1-polysilicon-1 D10#3contact@2645_metal-1-polysilicon-1##0 9.688
R1488 D10#3contact@2645_metal-1-polysilicon-1##0 D10#3contact@2645_metal-1-polysilicon-1##1 9.688
R1489 D10#3contact@2645_metal-1-polysilicon-1##1 D10#3contact@2645_metal-1-polysilicon-1##2 9.688
R1490 D10#3contact@2645_metal-1-polysilicon-1##2 D10#1pin@1468_polysilicon-1 9.688
R1491 S1#34pmos@519_poly-right S1#34pmos@519_poly-right##0 9.3
R1492 S1#34pmos@519_poly-right##0 S1#34pmos@519_poly-right##1 9.3
R1493 S1#34pmos@519_poly-right##1 S1#34pmos@519_poly-right##2 9.3
R1494 S1#34pmos@519_poly-right##2 S1#34pmos@519_poly-right##3 9.3
R1495 S1#34pmos@519_poly-right##3 S1#34pmos@519_poly-right##4 9.3
R1496 S1#34pmos@519_poly-right##4 S1#34pmos@519_poly-right##5 9.3
R1497 S1#34pmos@519_poly-right##5 S1#34pmos@519_poly-right##6 9.3
R1498 S1#34pmos@519_poly-right##6 S1#34pmos@519_poly-right##7 9.3
R1499 S1#34pmos@519_poly-right##7 S1#34pmos@519_poly-right##8 9.3
R1500 S1#34pmos@519_poly-right##8 S1 9.3
R1501 S1 S1##0 9.713
R1502 S1##0 S1##1 9.713
R1503 S1##1 S1##2 9.713
R1504 S1##2 S1##3 9.713
R1505 S1##3 S1##4 9.713
R1506 S1##4 S1##5 9.713
R1507 S1##5 S1##6 9.713
R1508 S1##6 S1##7 9.713
R1509 S1##7 S1##8 9.713
R1510 S1##8 S1##9 9.713
R1511 S1##9 S1##10 9.713
R1512 S1##10 S1##11 9.713
R1513 S1##11 S1##12 9.713
R1514 S1##12 S1##13 9.713
R1515 S1##13 S1#36nmos@520_poly-left 9.713
R1516 net@6958 net@6958##0 9.817
R1517 net@6958##0 net@6958##1 9.817
R1518 net@6958##1 net@6958##2 9.817
R1519 net@6958##2 net@6958##3 9.817
R1520 net@6958##3 net@6958##4 9.817
R1521 net@6958##4 net@6958##5 9.817
R1522 net@6958##5 net@6958##6 9.817
R1523 net@6958##6 net@6958##7 9.817
R1524 net@6958##7 net@6958##8 9.817
R1525 net@6958##8 net@6958##9 9.817
R1526 net@6958##9 net@6958##10 9.817
R1527 net@6958##10 net@6958#1pin@1474_polysilicon-1 9.817
R1528 net@6958#1pin@1474_polysilicon-1 net@6958#1pin@1474_polysilicon-1##0 9.3
R1529 net@6958#1pin@1474_polysilicon-1##0 net@6958#1pin@1474_polysilicon-1##1 9.3
R1530 net@6958#1pin@1474_polysilicon-1##1 net@6958#1pin@1474_polysilicon-1##2 9.3
R1531 net@6958#1pin@1474_polysilicon-1##2 net@6958#1pin@1474_polysilicon-1##3 9.3
R1532 net@6958#1pin@1474_polysilicon-1##3 net@6958#1pin@1474_polysilicon-1##4 9.3
R1533 net@6958#1pin@1474_polysilicon-1##4 net@6958#1pin@1474_polysilicon-1##5 9.3
R1534 net@6958#1pin@1474_polysilicon-1##5 net@6958#1pin@1474_polysilicon-1##6 9.3
R1535 net@6958#1pin@1474_polysilicon-1##6 net@6958#1pin@1474_polysilicon-1##7 9.3
R1536 net@6958#1pin@1474_polysilicon-1##7 net@6958#1pin@1474_polysilicon-1##8 9.3
R1537 net@6958#1pin@1474_polysilicon-1##8 net@6958#1pin@1474_polysilicon-1##9 9.3
R1538 net@6958#1pin@1474_polysilicon-1##9 net@6958#1pin@1474_polysilicon-1##10 9.3
R1539 net@6958#1pin@1474_polysilicon-1##10 net@6958#1pin@1474_polysilicon-1##11 9.3
R1540 net@6958#1pin@1474_polysilicon-1##11 net@6958#2nmos@522_poly-left 9.3
R1541 net@6958#3contact@2657_metal-1-polysilicon-1 net@6958#3contact@2657_metal-1-polysilicon-1##0 5.425
R1542 net@6958#3contact@2657_metal-1-polysilicon-1##0 net@6958#1pin@1474_polysilicon-1 5.425
R1543 net@6938#10pmos@521_poly-right net@6938#11pin@1475_polysilicon-1 6.2
R1544 net@6938#11pin@1475_polysilicon-1 net@6938#11pin@1475_polysilicon-1##0 9.688
R1545 net@6938#11pin@1475_polysilicon-1##0 net@6938#11pin@1475_polysilicon-1##1 9.688
R1546 net@6938#11pin@1475_polysilicon-1##1 net@6938#11pin@1475_polysilicon-1##2 9.688
R1547 net@6938#11pin@1475_polysilicon-1##2 net@6938#11pin@1475_polysilicon-1##3 9.688
R1548 net@6938#11pin@1475_polysilicon-1##3 net@6938#11pin@1475_polysilicon-1##4 9.688
R1549 net@6938#11pin@1475_polysilicon-1##4 net@6938#11pin@1475_polysilicon-1##5 9.688
R1550 net@6938#11pin@1475_polysilicon-1##5 net@6938#11pin@1475_polysilicon-1##6 9.688
R1551 net@6938#11pin@1475_polysilicon-1##6 net@6938#11pin@1475_polysilicon-1##7 9.688
R1552 net@6938#11pin@1475_polysilicon-1##7 net@6938#11pin@1475_polysilicon-1##8 9.688
R1553 net@6938#11pin@1475_polysilicon-1##8 net@6938#11pin@1475_polysilicon-1##9 9.688
R1554 net@6938#11pin@1475_polysilicon-1##9 net@6938#11pin@1475_polysilicon-1##10 9.688
R1555 net@6938#11pin@1475_polysilicon-1##10 net@6938#11pin@1475_polysilicon-1##11 9.688
R1556 net@6938#11pin@1475_polysilicon-1##11 net@6938#11pin@1475_polysilicon-1##12 9.688
R1557 net@6938#11pin@1475_polysilicon-1##12 net@6938#11pin@1475_polysilicon-1##13 9.688
R1558 net@6938#11pin@1475_polysilicon-1##13 net@6938#11pin@1475_polysilicon-1##14 9.688
R1559 net@6938#11pin@1475_polysilicon-1##14 net@6938#11pin@1475_polysilicon-1##15 9.688
R1560 net@6938#11pin@1475_polysilicon-1##15 net@6938#11pin@1475_polysilicon-1##16 9.688
R1561 net@6938#11pin@1475_polysilicon-1##16 net@6938#11pin@1475_polysilicon-1##17 9.688
R1562 net@6938#11pin@1475_polysilicon-1##17 net@6938#11pin@1475_polysilicon-1##18 9.688
R1563 net@6938#11pin@1475_polysilicon-1##18 net@6938#11pin@1475_polysilicon-1##19 9.688
R1564 net@6938#11pin@1475_polysilicon-1##19 net@6938#11pin@1475_polysilicon-1##20 9.688
R1565 net@6938#11pin@1475_polysilicon-1##20 net@6938#11pin@1475_polysilicon-1##21 9.688
R1566 net@6938#11pin@1475_polysilicon-1##21 net@6938#11pin@1475_polysilicon-1##22 9.688
R1567 net@6938#11pin@1475_polysilicon-1##22 net@6938#12nmos@521_poly-right 9.688
R1568 net@6938 net@6938##0 8.68
R1569 net@6938##0 net@6938##1 8.68
R1570 net@6938##1 net@6938##2 8.68
R1571 net@6938##2 net@6938##3 8.68
R1572 net@6938##3 net@6938#11pin@1475_polysilicon-1 8.68
R1573 net@6967 net@6967 0
R1574 net@6908#11pmos@507_poly-right net@6908#11pmos@507_poly-right##0 9.743
R1575 net@6908#11pmos@507_poly-right##0 net@6908#11pmos@507_poly-right##1 9.743
R1576 net@6908#11pmos@507_poly-right##1 net@6908#11pmos@507_poly-right##2 9.743
R1577 net@6908#11pmos@507_poly-right##2 net@6908#11pmos@507_poly-right##3 9.743
R1578 net@6908#11pmos@507_poly-right##3 net@6908#11pmos@507_poly-right##4 9.743
R1579 net@6908#11pmos@507_poly-right##4 net@6908#11pmos@507_poly-right##5 9.743
R1580 net@6908#11pmos@507_poly-right##5 net@6908#11pmos@507_poly-right##6 9.743
R1581 net@6908#11pmos@507_poly-right##6 net@6908#11pmos@507_poly-right##7 9.743
R1582 net@6908#11pmos@507_poly-right##7 net@6908#11pmos@507_poly-right##8 9.743
R1583 net@6908#11pmos@507_poly-right##8 net@6908#11pmos@507_poly-right##9 9.743
R1584 net@6908#11pmos@507_poly-right##9 net@6908#11pmos@507_poly-right##10 9.743
R1585 net@6908#11pmos@507_poly-right##10 net@6908#11pmos@507_poly-right##11 9.743
R1586 net@6908#11pmos@507_poly-right##11 net@6908#11pmos@507_poly-right##12 9.743
R1587 net@6908#11pmos@507_poly-right##12 net@6908#11pmos@507_poly-right##13 9.743
R1588 net@6908#11pmos@507_poly-right##13 net@6908#11pmos@507_poly-right##14 9.743
R1589 net@6908#11pmos@507_poly-right##14 net@6908#11pmos@507_poly-right##15 9.743
R1590 net@6908#11pmos@507_poly-right##15 net@6908#11pmos@507_poly-right##16 9.743
R1591 net@6908#11pmos@507_poly-right##16 net@6908#11pmos@507_poly-right##17 9.743
R1592 net@6908#11pmos@507_poly-right##17 net@6908#11pmos@507_poly-right##18 9.743
R1593 net@6908#11pmos@507_poly-right##18 net@6908#11pmos@507_poly-right##19 9.743
R1594 net@6908#11pmos@507_poly-right##19 net@6908#12pin@1446_polysilicon-1 9.743
R1595 net@6908#12pin@1446_polysilicon-1 net@6908#12pin@1446_polysilicon-1##0 8.525
R1596 net@6908#12pin@1446_polysilicon-1##0 net@6908#12pin@1446_polysilicon-1##1 8.525
R1597 net@6908#12pin@1446_polysilicon-1##1 net@6908#12pin@1446_polysilicon-1##2 8.525
R1598 net@6908#12pin@1446_polysilicon-1##2 net@6908#13nmos@508_poly-right 8.525
R1599 net@6908 net@6908##0 9.042
R1600 net@6908##0 net@6908##1 9.042
R1601 net@6908##1 net@6908##2 9.042
R1602 net@6908##2 net@6908##3 9.042
R1603 net@6908##3 net@6908##4 9.042
R1604 net@6908##4 net@6908#12pin@1446_polysilicon-1 9.042
R1605 net@6993 net@6993##0 9.704
R1606 net@6993##0 net@6993##1 9.704
R1607 net@6993##1 net@6993##2 9.704
R1608 net@6993##2 net@6993##3 9.704
R1609 net@6993##3 net@6993##4 9.704
R1610 net@6993##4 net@6993##5 9.704
R1611 net@6993##5 net@6993##6 9.704
R1612 net@6993##6 net@6993##7 9.704
R1613 net@6993##7 net@6993##8 9.704
R1614 net@6993##8 net@6993##9 9.704
R1615 net@6993##9 net@6993##10 9.704
R1616 net@6993##10 net@6993##11 9.704
R1617 net@6993##11 net@6993##12 9.704
R1618 net@6993##12 net@6993##13 9.704
R1619 net@6993##13 net@6993##14 9.704
R1620 net@6993##14 net@6993##15 9.704
R1621 net@6993##15 net@6993##16 9.704
R1622 net@6993##16 net@6993##17 9.704
R1623 net@6993##17 net@6993##18 9.704
R1624 net@6993##18 net@6993##19 9.704
R1625 net@6993##19 net@6993##20 9.704
R1626 net@6993##20 net@6993##21 9.704
R1627 net@6993##21 net@6993#1pin@1448_polysilicon-1 9.704
R1628 net@6993#1pin@1448_polysilicon-1 net@6993#1pin@1448_polysilicon-1##0 7.75
R1629 net@6993#1pin@1448_polysilicon-1##0 net@6993#2pmos@508_poly-right 7.75
R1630 net@6993#3contact@2595_metal-1-polysilicon-1 net@6993#3contact@2595_metal-1-polysilicon-1##0 9.3
R1631 net@6993#3contact@2595_metal-1-polysilicon-1##0 net@6993#3contact@2595_metal-1-polysilicon-1##1 9.3
R1632 net@6993#3contact@2595_metal-1-polysilicon-1##1 net@6993#3contact@2595_metal-1-polysilicon-1##2 9.3
R1633 net@6993#3contact@2595_metal-1-polysilicon-1##2 net@6993#3contact@2595_metal-1-polysilicon-1##3 9.3
R1634 net@6993#3contact@2595_metal-1-polysilicon-1##3 net@6993#1pin@1448_polysilicon-1 9.3
R1635 net@6895#4pmos@506_poly-right net@6895#4pmos@506_poly-right##0 8.783
R1636 net@6895#4pmos@506_poly-right##0 net@6895#4pmos@506_poly-right##1 8.783
R1637 net@6895#4pmos@506_poly-right##1 net@6895#4pmos@506_poly-right##2 8.783
R1638 net@6895#4pmos@506_poly-right##2 net@6895#4pmos@506_poly-right##3 8.783
R1639 net@6895#4pmos@506_poly-right##3 net@6895#4pmos@506_poly-right##4 8.783
R1640 net@6895#4pmos@506_poly-right##4 net@6895 8.783
R1641 net@6895 net@6895##0 9.789
R1642 net@6895##0 net@6895##1 9.789
R1643 net@6895##1 net@6895##2 9.789
R1644 net@6895##2 net@6895##3 9.789
R1645 net@6895##3 net@6895##4 9.789
R1646 net@6895##4 net@6895##5 9.789
R1647 net@6895##5 net@6895##6 9.789
R1648 net@6895##6 net@6895##7 9.789
R1649 net@6895##7 net@6895##8 9.789
R1650 net@6895##8 net@6895##9 9.789
R1651 net@6895##9 net@6895##10 9.789
R1652 net@6895##10 net@6895##11 9.789
R1653 net@6895##11 net@6895##12 9.789
R1654 net@6895##12 net@6895##13 9.789
R1655 net@6895##13 net@6895##14 9.789
R1656 net@6895##14 net@6895##15 9.789
R1657 net@6895##15 net@6895##16 9.789
R1658 net@6895##16 net@6895##17 9.789
R1659 net@6895##17 net@6895#6nmos@507_poly-left 9.789
R1660 net@6931#4nmos@509_poly-left net@6931#4nmos@509_poly-left##0 9.756
R1661 net@6931#4nmos@509_poly-left##0 net@6931#4nmos@509_poly-left##1 9.756
R1662 net@6931#4nmos@509_poly-left##1 net@6931#4nmos@509_poly-left##2 9.756
R1663 net@6931#4nmos@509_poly-left##2 net@6931#4nmos@509_poly-left##3 9.756
R1664 net@6931#4nmos@509_poly-left##3 net@6931#4nmos@509_poly-left##4 9.756
R1665 net@6931#4nmos@509_poly-left##4 net@6931#4nmos@509_poly-left##5 9.756
R1666 net@6931#4nmos@509_poly-left##5 net@6931#4nmos@509_poly-left##6 9.756
R1667 net@6931#4nmos@509_poly-left##6 net@6931#4nmos@509_poly-left##7 9.756
R1668 net@6931#4nmos@509_poly-left##7 net@6931#4nmos@509_poly-left##8 9.756
R1669 net@6931#4nmos@509_poly-left##8 net@6931#4nmos@509_poly-left##9 9.756
R1670 net@6931#4nmos@509_poly-left##9 net@6931#4nmos@509_poly-left##10 9.756
R1671 net@6931#4nmos@509_poly-left##10 net@6931#4nmos@509_poly-left##11 9.756
R1672 net@6931#4nmos@509_poly-left##11 net@6931#4nmos@509_poly-left##12 9.756
R1673 net@6931#4nmos@509_poly-left##12 net@6931#4nmos@509_poly-left##13 9.756
R1674 net@6931#4nmos@509_poly-left##13 net@6931#4nmos@509_poly-left##14 9.756
R1675 net@6931#4nmos@509_poly-left##14 net@6931#4nmos@509_poly-left##15 9.756
R1676 net@6931#4nmos@509_poly-left##15 net@6931#5contact@2609_metal-1-polysilicon-1 9.756
R1677 net@6931#5contact@2609_metal-1-polysilicon-1 net@6931#5contact@2609_metal-1-polysilicon-1##0 9.106
R1678 net@6931#5contact@2609_metal-1-polysilicon-1##0 net@6931#5contact@2609_metal-1-polysilicon-1##1 9.106
R1679 net@6931#5contact@2609_metal-1-polysilicon-1##1 net@6931#5contact@2609_metal-1-polysilicon-1##2 9.106
R1680 net@6931#5contact@2609_metal-1-polysilicon-1##2 net@6931#5contact@2609_metal-1-polysilicon-1##3 9.106
R1681 net@6931#5contact@2609_metal-1-polysilicon-1##3 net@6931#5contact@2609_metal-1-polysilicon-1##4 9.106
R1682 net@6931#5contact@2609_metal-1-polysilicon-1##4 net@6931#5contact@2609_metal-1-polysilicon-1##5 9.106
R1683 net@6931#5contact@2609_metal-1-polysilicon-1##5 net@6931#5contact@2609_metal-1-polysilicon-1##6 9.106
R1684 net@6931#5contact@2609_metal-1-polysilicon-1##6 net@6931#6pmos@510_poly-right 9.106
R1685 net@7002 net@7002##0 9.574
R1686 net@7002##0 net@7002##1 9.574
R1687 net@7002##1 net@7002##2 9.574
R1688 net@7002##2 net@7002##3 9.574
R1689 net@7002##3 net@7002##4 9.574
R1690 net@7002##4 net@7002##5 9.574
R1691 net@7002##5 net@7002##6 9.574
R1692 net@7002##6 net@7002##7 9.574
R1693 net@7002##7 net@7002##8 9.574
R1694 net@7002##8 net@7002##9 9.574
R1695 net@7002##9 net@7002##10 9.574
R1696 net@7002##10 net@7002##11 9.574
R1697 net@7002##11 net@7002##12 9.574
R1698 net@7002##12 net@7002##13 9.574
R1699 net@7002##13 net@7002##14 9.574
R1700 net@7002##14 net@7002##15 9.574
R1701 net@7002##15 net@7002#1contact@2610_metal-1-polysilicon-1 9.574
R1702 net@7002#1contact@2610_metal-1-polysilicon-1 net@7002#1contact@2610_metal-1-polysilicon-1##0 9.494
R1703 net@7002#1contact@2610_metal-1-polysilicon-1##0 net@7002#1contact@2610_metal-1-polysilicon-1##1 9.494
R1704 net@7002#1contact@2610_metal-1-polysilicon-1##1 net@7002#1contact@2610_metal-1-polysilicon-1##2 9.494
R1705 net@7002#1contact@2610_metal-1-polysilicon-1##2 net@7002#1contact@2610_metal-1-polysilicon-1##3 9.494
R1706 net@7002#1contact@2610_metal-1-polysilicon-1##3 net@7002#1contact@2610_metal-1-polysilicon-1##4 9.494
R1707 net@7002#1contact@2610_metal-1-polysilicon-1##4 net@7002#1contact@2610_metal-1-polysilicon-1##5 9.494
R1708 net@7002#1contact@2610_metal-1-polysilicon-1##5 net@7002#1contact@2610_metal-1-polysilicon-1##6 9.494
R1709 net@7002#1contact@2610_metal-1-polysilicon-1##6 net@7002#2nmos@510_poly-left 9.494
R1710 net@6993#3contact@2595_metal-1-polysilicon-1 net@6993#3contact@2595_metal-1-polysilicon-1 0
R1711 net@7018 net@7018#1pin@1482_polysilicon-1 7.75
R1712 net@7018#1pin@1482_polysilicon-1 net@7018#1pin@1482_polysilicon-1##0 9.623
R1713 net@7018#1pin@1482_polysilicon-1##0 net@7018#1pin@1482_polysilicon-1##1 9.623
R1714 net@7018#1pin@1482_polysilicon-1##1 net@7018#1pin@1482_polysilicon-1##2 9.623
R1715 net@7018#1pin@1482_polysilicon-1##2 net@7018#1pin@1482_polysilicon-1##3 9.623
R1716 net@7018#1pin@1482_polysilicon-1##3 net@7018#1pin@1482_polysilicon-1##4 9.623
R1717 net@7018#1pin@1482_polysilicon-1##4 net@7018#1pin@1482_polysilicon-1##5 9.623
R1718 net@7018#1pin@1482_polysilicon-1##5 net@7018#1pin@1482_polysilicon-1##6 9.623
R1719 net@7018#1pin@1482_polysilicon-1##6 net@7018#1pin@1482_polysilicon-1##7 9.623
R1720 net@7018#1pin@1482_polysilicon-1##7 net@7018#1pin@1482_polysilicon-1##8 9.623
R1721 net@7018#1pin@1482_polysilicon-1##8 net@7018#1pin@1482_polysilicon-1##9 9.623
R1722 net@7018#1pin@1482_polysilicon-1##9 net@7018#1pin@1482_polysilicon-1##10 9.623
R1723 net@7018#1pin@1482_polysilicon-1##10 net@7018#1pin@1482_polysilicon-1##11 9.623
R1724 net@7018#1pin@1482_polysilicon-1##11 net@7018#1pin@1482_polysilicon-1##12 9.623
R1725 net@7018#1pin@1482_polysilicon-1##12 net@7018#1pin@1482_polysilicon-1##13 9.623
R1726 net@7018#1pin@1482_polysilicon-1##13 net@7018#1pin@1482_polysilicon-1##14 9.623
R1727 net@7018#1pin@1482_polysilicon-1##14 net@7018#1pin@1482_polysilicon-1##15 9.623
R1728 net@7018#1pin@1482_polysilicon-1##15 net@7018#1pin@1482_polysilicon-1##16 9.623
R1729 net@7018#1pin@1482_polysilicon-1##16 net@7018#1pin@1482_polysilicon-1##17 9.623
R1730 net@7018#1pin@1482_polysilicon-1##17 net@7018#1pin@1482_polysilicon-1##18 9.623
R1731 net@7018#1pin@1482_polysilicon-1##18 net@7018#1pin@1482_polysilicon-1##19 9.623
R1732 net@7018#1pin@1482_polysilicon-1##19 net@7018#1pin@1482_polysilicon-1##20 9.623
R1733 net@7018#1pin@1482_polysilicon-1##20 net@7018#1pin@1482_polysilicon-1##21 9.623
R1734 net@7018#1pin@1482_polysilicon-1##21 net@7018#1pin@1482_polysilicon-1##22 9.623
R1735 net@7018#1pin@1482_polysilicon-1##22 net@7018#2nmos@525_poly-right 9.623
R1736 net@7018#3contact@2674_metal-1-polysilicon-1 net@7018#3contact@2674_metal-1-polysilicon-1##0 8.68
R1737 net@7018#3contact@2674_metal-1-polysilicon-1##0 net@7018#3contact@2674_metal-1-polysilicon-1##1 8.68
R1738 net@7018#3contact@2674_metal-1-polysilicon-1##1 net@7018#3contact@2674_metal-1-polysilicon-1##2 8.68
R1739 net@7018#3contact@2674_metal-1-polysilicon-1##2 net@7018#3contact@2674_metal-1-polysilicon-1##3 8.68
R1740 net@7018#3contact@2674_metal-1-polysilicon-1##3 net@7018#1pin@1482_polysilicon-1 8.68
R1741 net@7002#4contact@2666_metal-1-n-act net@7002#4contact@2666_metal-1-n-act 0
R1742 S1#38pmos@523_poly-right S1#38pmos@523_poly-right##0 9.482
R1743 S1#38pmos@523_poly-right##0 S1#38pmos@523_poly-right##1 9.482
R1744 S1#38pmos@523_poly-right##1 S1#38pmos@523_poly-right##2 9.482
R1745 S1#38pmos@523_poly-right##2 S1#38pmos@523_poly-right##3 9.482
R1746 S1#38pmos@523_poly-right##3 S1#38pmos@523_poly-right##4 9.482
R1747 S1#38pmos@523_poly-right##4 S1#38pmos@523_poly-right##5 9.482
R1748 S1#38pmos@523_poly-right##5 S1#38pmos@523_poly-right##6 9.482
R1749 S1#38pmos@523_poly-right##6 S1#38pmos@523_poly-right##7 9.482
R1750 S1#38pmos@523_poly-right##7 S1#38pmos@523_poly-right##8 9.482
R1751 S1#38pmos@523_poly-right##8 S1#38pmos@523_poly-right##9 9.482
R1752 S1#38pmos@523_poly-right##9 S1#38pmos@523_poly-right##10 9.482
R1753 S1#38pmos@523_poly-right##10 S1#38pmos@523_poly-right##11 9.482
R1754 S1#38pmos@523_poly-right##11 S1#38pmos@523_poly-right##12 9.482
R1755 S1#38pmos@523_poly-right##12 S1#38pmos@523_poly-right##13 9.482
R1756 S1#38pmos@523_poly-right##13 S1#38pmos@523_poly-right##14 9.482
R1757 S1#38pmos@523_poly-right##14 S1#38pmos@523_poly-right##15 9.482
R1758 S1#38pmos@523_poly-right##15 S1 9.482
R1759 S1 S1##0 9.688
R1760 S1##0 S1##1 9.688
R1761 S1##1 S1##2 9.688
R1762 S1##2 S1##3 9.688
R1763 S1##3 S1##4 9.688
R1764 S1##4 S1##5 9.688
R1765 S1##5 S1##6 9.688
R1766 S1##6 S1#40nmos@524_poly-left 9.688
R1767 S0#41pmos@526_poly-right S0#41pmos@526_poly-right##0 9.871
R1768 S0#41pmos@526_poly-right##0 S0#41pmos@526_poly-right##1 9.871
R1769 S0#41pmos@526_poly-right##1 S0#41pmos@526_poly-right##2 9.871
R1770 S0#41pmos@526_poly-right##2 S0#41pmos@526_poly-right##3 9.871
R1771 S0#41pmos@526_poly-right##3 S0#41pmos@526_poly-right##4 9.871
R1772 S0#41pmos@526_poly-right##4 S0#41pmos@526_poly-right##5 9.871
R1773 S0#41pmos@526_poly-right##5 S0#41pmos@526_poly-right##6 9.871
R1774 S0#41pmos@526_poly-right##6 S0#41pmos@526_poly-right##7 9.871
R1775 S0#41pmos@526_poly-right##7 S0#41pmos@526_poly-right##8 9.871
R1776 S0#41pmos@526_poly-right##8 S0#41pmos@526_poly-right##9 9.871
R1777 S0#41pmos@526_poly-right##9 S0#41pmos@526_poly-right##10 9.871
R1778 S0#41pmos@526_poly-right##10 S0#41pmos@526_poly-right##11 9.871
R1779 S0#41pmos@526_poly-right##11 S0#41pmos@526_poly-right##12 9.871
R1780 S0#41pmos@526_poly-right##12 S0#41pmos@526_poly-right##13 9.871
R1781 S0#41pmos@526_poly-right##13 S0#41pmos@526_poly-right##14 9.871
R1782 S0#41pmos@526_poly-right##14 S0#41pmos@526_poly-right##15 9.871
R1783 S0#41pmos@526_poly-right##15 S0#41pmos@526_poly-right##16 9.871
R1784 S0#41pmos@526_poly-right##16 S0#41pmos@526_poly-right##17 9.871
R1785 S0#41pmos@526_poly-right##17 S0#42pin@1481_polysilicon-1 9.871
R1786 S0#42pin@1481_polysilicon-1 S0#42pin@1481_polysilicon-1##0 8.525
R1787 S0#42pin@1481_polysilicon-1##0 S0#42pin@1481_polysilicon-1##1 8.525
R1788 S0#42pin@1481_polysilicon-1##1 S0#42pin@1481_polysilicon-1##2 8.525
R1789 S0#42pin@1481_polysilicon-1##2 S0#42pin@1481_polysilicon-1##3 8.525
R1790 S0#42pin@1481_polysilicon-1##3 S0#42pin@1481_polysilicon-1##4 8.525
R1791 S0#42pin@1481_polysilicon-1##4 S0#43nmos@526_poly-left 8.525
R1792 S0 S0##0 5.425
R1793 S0##0 S0#42pin@1481_polysilicon-1 5.425
R1794 net@6913#3contact@2676_metal-1-p-act net@6913#3contact@2676_metal-1-p-act 0
R1795 S0#46pmos@528_poly-right S0#46pmos@528_poly-right##0 9.817
R1796 S0#46pmos@528_poly-right##0 S0#46pmos@528_poly-right##1 9.817
R1797 S0#46pmos@528_poly-right##1 S0#46pmos@528_poly-right##2 9.817
R1798 S0#46pmos@528_poly-right##2 S0#46pmos@528_poly-right##3 9.817
R1799 S0#46pmos@528_poly-right##3 S0#46pmos@528_poly-right##4 9.817
R1800 S0#46pmos@528_poly-right##4 S0#46pmos@528_poly-right##5 9.817
R1801 S0#46pmos@528_poly-right##5 S0#46pmos@528_poly-right##6 9.817
R1802 S0#46pmos@528_poly-right##6 S0#46pmos@528_poly-right##7 9.817
R1803 S0#46pmos@528_poly-right##7 S0#46pmos@528_poly-right##8 9.817
R1804 S0#46pmos@528_poly-right##8 S0#46pmos@528_poly-right##9 9.817
R1805 S0#46pmos@528_poly-right##9 S0#46pmos@528_poly-right##10 9.817
R1806 S0#46pmos@528_poly-right##10 S0#46pmos@528_poly-right##11 9.817
R1807 S0#46pmos@528_poly-right##11 S0#46pmos@528_poly-right##12 9.817
R1808 S0#46pmos@528_poly-right##12 S0#46pmos@528_poly-right##13 9.817
R1809 S0#46pmos@528_poly-right##13 S0#46pmos@528_poly-right##14 9.817
R1810 S0#46pmos@528_poly-right##14 S0#46pmos@528_poly-right##15 9.817
R1811 S0#46pmos@528_poly-right##15 S0#46pmos@528_poly-right##16 9.817
R1812 S0#46pmos@528_poly-right##16 S0#46pmos@528_poly-right##17 9.817
R1813 S0#46pmos@528_poly-right##17 S0#46pmos@528_poly-right##18 9.817
R1814 S0#46pmos@528_poly-right##18 S0#46pmos@528_poly-right##19 9.817
R1815 S0#46pmos@528_poly-right##19 S0#47pin@1483_polysilicon-1 9.817
R1816 S0#47pin@1483_polysilicon-1 S0#47pin@1483_polysilicon-1##0 8.138
R1817 S0#47pin@1483_polysilicon-1##0 S0#47pin@1483_polysilicon-1##1 8.138
R1818 S0#47pin@1483_polysilicon-1##1 S0#47pin@1483_polysilicon-1##2 8.138
R1819 S0#47pin@1483_polysilicon-1##2 S0#48nmos@528_poly-right 8.138
R1820 S0 S0##0 9.713
R1821 S0##0 S0##1 9.713
R1822 S0##1 S0##2 9.713
R1823 S0##2 S0##3 9.713
R1824 S0##3 S0##4 9.713
R1825 S0##4 S0##5 9.713
R1826 S0##5 S0##6 9.713
R1827 S0##6 S0##7 9.713
R1828 S0##7 S0##8 9.713
R1829 S0##8 S0##9 9.713
R1830 S0##9 S0##10 9.713
R1831 S0##10 S0##11 9.713
R1832 S0##11 S0##12 9.713
R1833 S0##12 S0##13 9.713
R1834 S0##13 S0#47pin@1483_polysilicon-1 9.713
R1835 net@6958#3contact@2657_metal-1-polysilicon-1 net@6958#3contact@2657_metal-1-polysilicon-1 0
R1836 S1#45pmos@527_poly-right S1#45pmos@527_poly-right##0 9.623
R1837 S1#45pmos@527_poly-right##0 S1#45pmos@527_poly-right##1 9.623
R1838 S1#45pmos@527_poly-right##1 S1#45pmos@527_poly-right##2 9.623
R1839 S1#45pmos@527_poly-right##2 S1#45pmos@527_poly-right##3 9.623
R1840 S1#45pmos@527_poly-right##3 S1#45pmos@527_poly-right##4 9.623
R1841 S1#45pmos@527_poly-right##4 S1#45pmos@527_poly-right##5 9.623
R1842 S1#45pmos@527_poly-right##5 S1#45pmos@527_poly-right##6 9.623
R1843 S1#45pmos@527_poly-right##6 S1#45pmos@527_poly-right##7 9.623
R1844 S1#45pmos@527_poly-right##7 S1#45pmos@527_poly-right##8 9.623
R1845 S1#45pmos@527_poly-right##8 S1#45pmos@527_poly-right##9 9.623
R1846 S1#45pmos@527_poly-right##9 S1#45pmos@527_poly-right##10 9.623
R1847 S1#45pmos@527_poly-right##10 S1#45pmos@527_poly-right##11 9.623
R1848 S1#45pmos@527_poly-right##11 S1#45pmos@527_poly-right##12 9.623
R1849 S1#45pmos@527_poly-right##12 S1#45pmos@527_poly-right##13 9.623
R1850 S1#45pmos@527_poly-right##13 S1#45pmos@527_poly-right##14 9.623
R1851 S1#45pmos@527_poly-right##14 S1#45pmos@527_poly-right##15 9.623
R1852 S1#45pmos@527_poly-right##15 S1#45pmos@527_poly-right##16 9.623
R1853 S1#45pmos@527_poly-right##16 S1#45pmos@527_poly-right##17 9.623
R1854 S1#45pmos@527_poly-right##17 S1#45pmos@527_poly-right##18 9.623
R1855 S1#45pmos@527_poly-right##18 S1#45pmos@527_poly-right##19 9.623
R1856 S1#45pmos@527_poly-right##19 S1#45pmos@527_poly-right##20 9.623
R1857 S1#45pmos@527_poly-right##20 S1#45pmos@527_poly-right##21 9.623
R1858 S1#45pmos@527_poly-right##21 S1#45pmos@527_poly-right##22 9.623
R1859 S1#45pmos@527_poly-right##22 S1#46pin@1484_polysilicon-1 9.623
R1860 S1#46pin@1484_polysilicon-1 S1#47nmos@527_poly-right 7.75
R1861 S1 S1##0 6.2
R1862 S1##0 S1#46pin@1484_polysilicon-1 6.2
R1863 D11#3nmos@523_poly-left D11#3nmos@523_poly-left##0 9.92
R1864 D11#3nmos@523_poly-left##0 D11#3nmos@523_poly-left##1 9.92
R1865 D11#3nmos@523_poly-left##1 D11#3nmos@523_poly-left##2 9.92
R1866 D11#3nmos@523_poly-left##2 D11#3nmos@523_poly-left##3 9.92
R1867 D11#3nmos@523_poly-left##3 D11#3nmos@523_poly-left##4 9.92
R1868 D11#3nmos@523_poly-left##4 D11#3nmos@523_poly-left##5 9.92
R1869 D11#3nmos@523_poly-left##5 D11#3nmos@523_poly-left##6 9.92
R1870 D11#3nmos@523_poly-left##6 D11#3nmos@523_poly-left##7 9.92
R1871 D11#3nmos@523_poly-left##7 D11#3nmos@523_poly-left##8 9.92
R1872 D11#3nmos@523_poly-left##8 D11#4pin@1485_polysilicon-1 9.92
R1873 D11#4pin@1485_polysilicon-1 D11#4pin@1485_polysilicon-1##0 9.964
R1874 D11#4pin@1485_polysilicon-1##0 D11#4pin@1485_polysilicon-1##1 9.964
R1875 D11#4pin@1485_polysilicon-1##1 D11#4pin@1485_polysilicon-1##2 9.964
R1876 D11#4pin@1485_polysilicon-1##2 D11#4pin@1485_polysilicon-1##3 9.964
R1877 D11#4pin@1485_polysilicon-1##3 D11#4pin@1485_polysilicon-1##4 9.964
R1878 D11#4pin@1485_polysilicon-1##4 D11#4pin@1485_polysilicon-1##5 9.964
R1879 D11#4pin@1485_polysilicon-1##5 D11#4pin@1485_polysilicon-1##6 9.964
R1880 D11#4pin@1485_polysilicon-1##6 D11#4pin@1485_polysilicon-1##7 9.964
R1881 D11#4pin@1485_polysilicon-1##7 D11#4pin@1485_polysilicon-1##8 9.964
R1882 D11#4pin@1485_polysilicon-1##8 D11#4pin@1485_polysilicon-1##9 9.964
R1883 D11#4pin@1485_polysilicon-1##9 D11#4pin@1485_polysilicon-1##10 9.964
R1884 D11#4pin@1485_polysilicon-1##10 D11#4pin@1485_polysilicon-1##11 9.964
R1885 D11#4pin@1485_polysilicon-1##11 D11#4pin@1485_polysilicon-1##12 9.964
R1886 D11#4pin@1485_polysilicon-1##12 D11#5pmos@524_poly-right 9.964
R1887 D11 D11##0 8.06
R1888 D11##0 D11##1 8.06
R1889 D11##1 D11##2 8.06
R1890 D11##2 D11##3 8.06
R1891 D11##3 D11#4pin@1485_polysilicon-1 8.06
R1892 D10 D10#3contact@2645_metal-1-polysilicon-1 4.576
R1893 net@6913#3contact@2676_metal-1-p-act net@6913#1contact@2639_metal-1-polysilicon-1 4.706
R1894 D9 D9#3contact@2629_metal-1-polysilicon-1 6.838
R1895 D8#0contact@2704_metal-1-metal-2 D8 9.087
R1896 net@6931 net@6931#5contact@2609_metal-1-polysilicon-1 5.07
R1897 S0#39contact@2641_metal-1-polysilicon-1 S0 4.68
R1898 net@7002#4contact@2666_metal-1-n-act net@7002#1contact@2610_metal-1-polysilicon-1 7.254
R1899 D8#3nmos@511_poly-left D8#3nmos@511_poly-left##0 9.723
R1900 D8#3nmos@511_poly-left##0 D8#3nmos@511_poly-left##1 9.723
R1901 D8#3nmos@511_poly-left##1 D8#3nmos@511_poly-left##2 9.723
R1902 D8#3nmos@511_poly-left##2 D8#3nmos@511_poly-left##3 9.723
R1903 D8#3nmos@511_poly-left##3 D8#3nmos@511_poly-left##4 9.723
R1904 D8#3nmos@511_poly-left##4 D8#3nmos@511_poly-left##5 9.723
R1905 D8#3nmos@511_poly-left##5 D8#3nmos@511_poly-left##6 9.723
R1906 D8#3nmos@511_poly-left##6 D8#3nmos@511_poly-left##7 9.723
R1907 D8#3nmos@511_poly-left##7 D8#3nmos@511_poly-left##8 9.723
R1908 D8#3nmos@511_poly-left##8 D8#3nmos@511_poly-left##9 9.723
R1909 D8#3nmos@511_poly-left##9 D8#3nmos@511_poly-left##10 9.723
R1910 D8#3nmos@511_poly-left##10 D8#3nmos@511_poly-left##11 9.723
R1911 D8#3nmos@511_poly-left##11 D8#3nmos@511_poly-left##12 9.723
R1912 D8#3nmos@511_poly-left##12 D8#3nmos@511_poly-left##13 9.723
R1913 D8#3nmos@511_poly-left##13 D8#3nmos@511_poly-left##14 9.723
R1914 D8#3nmos@511_poly-left##14 D8#3nmos@511_poly-left##15 9.723
R1915 D8#3nmos@511_poly-left##15 D8#3nmos@511_poly-left##16 9.723
R1916 D8#3nmos@511_poly-left##16 D8#3nmos@511_poly-left##17 9.723
R1917 D8#3nmos@511_poly-left##17 D8#3nmos@511_poly-left##18 9.723
R1918 D8#3nmos@511_poly-left##18 D8#3nmos@511_poly-left##19 9.723
R1919 D8#3nmos@511_poly-left##19 D8#3nmos@511_poly-left##20 9.723
R1920 D8#3nmos@511_poly-left##20 D8#4pin@1452_polysilicon-1 9.723
R1921 D8#4pin@1452_polysilicon-1 D8#4pin@1452_polysilicon-1##0 8.267
R1922 D8#4pin@1452_polysilicon-1##0 D8#4pin@1452_polysilicon-1##1 8.267
R1923 D8#4pin@1452_polysilicon-1##1 D8#5pmos@512_poly-right 8.267
R1924 D8#0contact@2704_metal-1-metal-2 D8#0contact@2704_metal-1-metal-2##0 8.138
R1925 D8#0contact@2704_metal-1-metal-2##0 D8#0contact@2704_metal-1-metal-2##1 8.138
R1926 D8#0contact@2704_metal-1-metal-2##1 D8#0contact@2704_metal-1-metal-2##2 8.138
R1927 D8#0contact@2704_metal-1-metal-2##2 D8#4pin@1452_polysilicon-1 8.138
R1928 net@6958#16pmos@511_poly-right net@6958#16pmos@511_poly-right##0 9.817
R1929 net@6958#16pmos@511_poly-right##0 net@6958#16pmos@511_poly-right##1 9.817
R1930 net@6958#16pmos@511_poly-right##1 net@6958#16pmos@511_poly-right##2 9.817
R1931 net@6958#16pmos@511_poly-right##2 net@6958#16pmos@511_poly-right##3 9.817
R1932 net@6958#16pmos@511_poly-right##3 net@6958#16pmos@511_poly-right##4 9.817
R1933 net@6958#16pmos@511_poly-right##4 net@6958#16pmos@511_poly-right##5 9.817
R1934 net@6958#16pmos@511_poly-right##5 net@6958#16pmos@511_poly-right##6 9.817
R1935 net@6958#16pmos@511_poly-right##6 net@6958#16pmos@511_poly-right##7 9.817
R1936 net@6958#16pmos@511_poly-right##7 net@6958#16pmos@511_poly-right##8 9.817
R1937 net@6958#16pmos@511_poly-right##8 net@6958#16pmos@511_poly-right##9 9.817
R1938 net@6958#16pmos@511_poly-right##9 net@6958#16pmos@511_poly-right##10 9.817
R1939 net@6958#16pmos@511_poly-right##10 net@6958#3contact@2657_metal-1-polysilicon-1 9.817
R1940 net@6958#3contact@2657_metal-1-polysilicon-1 net@6958#3contact@2657_metal-1-polysilicon-1##0 9.3
R1941 net@6958#3contact@2657_metal-1-polysilicon-1##0 net@6958#3contact@2657_metal-1-polysilicon-1##1 9.3
R1942 net@6958#3contact@2657_metal-1-polysilicon-1##1 net@6958#3contact@2657_metal-1-polysilicon-1##2 9.3
R1943 net@6958#3contact@2657_metal-1-polysilicon-1##2 net@6958#3contact@2657_metal-1-polysilicon-1##3 9.3
R1944 net@6958#3contact@2657_metal-1-polysilicon-1##3 net@6958#3contact@2657_metal-1-polysilicon-1##4 9.3
R1945 net@6958#3contact@2657_metal-1-polysilicon-1##4 net@6958#3contact@2657_metal-1-polysilicon-1##5 9.3
R1946 net@6958#3contact@2657_metal-1-polysilicon-1##5 net@6958#3contact@2657_metal-1-polysilicon-1##6 9.3
R1947 net@6958#3contact@2657_metal-1-polysilicon-1##6 net@6958#3contact@2657_metal-1-polysilicon-1##7 9.3
R1948 net@6958#3contact@2657_metal-1-polysilicon-1##7 net@6958#3contact@2657_metal-1-polysilicon-1##8 9.3
R1949 net@6958#3contact@2657_metal-1-polysilicon-1##8 net@6958#3contact@2657_metal-1-polysilicon-1##9 9.3
R1950 net@6958#3contact@2657_metal-1-polysilicon-1##9 net@6958#3contact@2657_metal-1-polysilicon-1##10 9.3
R1951 net@6958#3contact@2657_metal-1-polysilicon-1##10 net@6958#3contact@2657_metal-1-polysilicon-1##11 9.3
R1952 net@6958#3contact@2657_metal-1-polysilicon-1##11 net@6958#18nmos@512_poly-left 9.3
R1953 net@6913#13pmos@514_poly-right net@6913#13pmos@514_poly-right##0 9.403
R1954 net@6913#13pmos@514_poly-right##0 net@6913#13pmos@514_poly-right##1 9.403
R1955 net@6913#13pmos@514_poly-right##1 net@6913#13pmos@514_poly-right##2 9.403
R1956 net@6913#13pmos@514_poly-right##2 net@6913#13pmos@514_poly-right##3 9.403
R1957 net@6913#13pmos@514_poly-right##3 net@6913#13pmos@514_poly-right##4 9.403
R1958 net@6913#13pmos@514_poly-right##4 net@6913#13pmos@514_poly-right##5 9.403
R1959 net@6913#13pmos@514_poly-right##5 net@6913#13pmos@514_poly-right##6 9.403
R1960 net@6913#13pmos@514_poly-right##6 net@6913#13pmos@514_poly-right##7 9.403
R1961 net@6913#13pmos@514_poly-right##7 net@6913#13pmos@514_poly-right##8 9.403
R1962 net@6913#13pmos@514_poly-right##8 net@6913#13pmos@514_poly-right##9 9.403
R1963 net@6913#13pmos@514_poly-right##9 net@6913#13pmos@514_poly-right##10 9.403
R1964 net@6913#13pmos@514_poly-right##10 net@6913#13pmos@514_poly-right##11 9.403
R1965 net@6913#13pmos@514_poly-right##11 net@6913#13pmos@514_poly-right##12 9.403
R1966 net@6913#13pmos@514_poly-right##12 net@6913#13pmos@514_poly-right##13 9.403
R1967 net@6913#13pmos@514_poly-right##13 net@6913#14pin@1458_polysilicon-1 9.403
R1968 net@6913#14pin@1458_polysilicon-1 net@6913#14pin@1458_polysilicon-1##0 9.765
R1969 net@6913#14pin@1458_polysilicon-1##0 net@6913#14pin@1458_polysilicon-1##1 9.765
R1970 net@6913#14pin@1458_polysilicon-1##1 net@6913#14pin@1458_polysilicon-1##2 9.765
R1971 net@6913#14pin@1458_polysilicon-1##2 net@6913#14pin@1458_polysilicon-1##3 9.765
R1972 net@6913#14pin@1458_polysilicon-1##3 net@6913#14pin@1458_polysilicon-1##4 9.765
R1973 net@6913#14pin@1458_polysilicon-1##4 net@6913#14pin@1458_polysilicon-1##5 9.765
R1974 net@6913#14pin@1458_polysilicon-1##5 net@6913#14pin@1458_polysilicon-1##6 9.765
R1975 net@6913#14pin@1458_polysilicon-1##6 net@6913#14pin@1458_polysilicon-1##7 9.765
R1976 net@6913#14pin@1458_polysilicon-1##7 net@6913#14pin@1458_polysilicon-1##8 9.765
R1977 net@6913#14pin@1458_polysilicon-1##8 net@6913#15nmos@514_poly-left 9.765
R1978 net@6913#1contact@2639_metal-1-polysilicon-1 net@6913#1contact@2639_metal-1-polysilicon-1##0 5.425
R1979 net@6913#1contact@2639_metal-1-polysilicon-1##0 net@6913#14pin@1458_polysilicon-1 5.425
R1980 net@7190 net@7190#1pin@1524_polysilicon-1 7.75
R1981 net@7190#1pin@1524_polysilicon-1 net@7190#1pin@1524_polysilicon-1##0 9.623
R1982 net@7190#1pin@1524_polysilicon-1##0 net@7190#1pin@1524_polysilicon-1##1 9.623
R1983 net@7190#1pin@1524_polysilicon-1##1 net@7190#1pin@1524_polysilicon-1##2 9.623
R1984 net@7190#1pin@1524_polysilicon-1##2 net@7190#1pin@1524_polysilicon-1##3 9.623
R1985 net@7190#1pin@1524_polysilicon-1##3 net@7190#1pin@1524_polysilicon-1##4 9.623
R1986 net@7190#1pin@1524_polysilicon-1##4 net@7190#1pin@1524_polysilicon-1##5 9.623
R1987 net@7190#1pin@1524_polysilicon-1##5 net@7190#1pin@1524_polysilicon-1##6 9.623
R1988 net@7190#1pin@1524_polysilicon-1##6 net@7190#1pin@1524_polysilicon-1##7 9.623
R1989 net@7190#1pin@1524_polysilicon-1##7 net@7190#1pin@1524_polysilicon-1##8 9.623
R1990 net@7190#1pin@1524_polysilicon-1##8 net@7190#1pin@1524_polysilicon-1##9 9.623
R1991 net@7190#1pin@1524_polysilicon-1##9 net@7190#1pin@1524_polysilicon-1##10 9.623
R1992 net@7190#1pin@1524_polysilicon-1##10 net@7190#1pin@1524_polysilicon-1##11 9.623
R1993 net@7190#1pin@1524_polysilicon-1##11 net@7190#1pin@1524_polysilicon-1##12 9.623
R1994 net@7190#1pin@1524_polysilicon-1##12 net@7190#1pin@1524_polysilicon-1##13 9.623
R1995 net@7190#1pin@1524_polysilicon-1##13 net@7190#1pin@1524_polysilicon-1##14 9.623
R1996 net@7190#1pin@1524_polysilicon-1##14 net@7190#1pin@1524_polysilicon-1##15 9.623
R1997 net@7190#1pin@1524_polysilicon-1##15 net@7190#1pin@1524_polysilicon-1##16 9.623
R1998 net@7190#1pin@1524_polysilicon-1##16 net@7190#1pin@1524_polysilicon-1##17 9.623
R1999 net@7190#1pin@1524_polysilicon-1##17 net@7190#1pin@1524_polysilicon-1##18 9.623
R2000 net@7190#1pin@1524_polysilicon-1##18 net@7190#1pin@1524_polysilicon-1##19 9.623
R2001 net@7190#1pin@1524_polysilicon-1##19 net@7190#1pin@1524_polysilicon-1##20 9.623
R2002 net@7190#1pin@1524_polysilicon-1##20 net@7190#1pin@1524_polysilicon-1##21 9.623
R2003 net@7190#1pin@1524_polysilicon-1##21 net@7190#1pin@1524_polysilicon-1##22 9.623
R2004 net@7190#1pin@1524_polysilicon-1##22 net@7190#2nmos@536_poly-right 9.623
R2005 net@7190#3contact@2744_metal-1-polysilicon-1 net@7190#3contact@2744_metal-1-polysilicon-1##0 8.68
R2006 net@7190#3contact@2744_metal-1-polysilicon-1##0 net@7190#3contact@2744_metal-1-polysilicon-1##1 8.68
R2007 net@7190#3contact@2744_metal-1-polysilicon-1##1 net@7190#3contact@2744_metal-1-polysilicon-1##2 8.68
R2008 net@7190#3contact@2744_metal-1-polysilicon-1##2 net@7190#3contact@2744_metal-1-polysilicon-1##3 8.68
R2009 net@7190#3contact@2744_metal-1-polysilicon-1##3 net@7190#1pin@1524_polysilicon-1 8.68
R2010 net@7194 net@7194 0
R2011 D13#0nmos@538_poly-left D13#0nmos@538_poly-left##0 9.953
R2012 D13#0nmos@538_poly-left##0 D13#0nmos@538_poly-left##1 9.953
R2013 D13#0nmos@538_poly-left##1 D13#0nmos@538_poly-left##2 9.953
R2014 D13#0nmos@538_poly-left##2 D13#0nmos@538_poly-left##3 9.953
R2015 D13#0nmos@538_poly-left##3 D13#0nmos@538_poly-left##4 9.953
R2016 D13#0nmos@538_poly-left##4 D13#0nmos@538_poly-left##5 9.953
R2017 D13#0nmos@538_poly-left##5 D13#0nmos@538_poly-left##6 9.953
R2018 D13#0nmos@538_poly-left##6 D13#0nmos@538_poly-left##7 9.953
R2019 D13#0nmos@538_poly-left##7 D13#0nmos@538_poly-left##8 9.953
R2020 D13#0nmos@538_poly-left##8 D13#0nmos@538_poly-left##9 9.953
R2021 D13#0nmos@538_poly-left##9 D13#0nmos@538_poly-left##10 9.953
R2022 D13#0nmos@538_poly-left##10 D13#0nmos@538_poly-left##11 9.953
R2023 D13#0nmos@538_poly-left##11 D13#0nmos@538_poly-left##12 9.953
R2024 D13#0nmos@538_poly-left##12 D13#0nmos@538_poly-left##13 9.953
R2025 D13#0nmos@538_poly-left##13 D13#0nmos@538_poly-left##14 9.953
R2026 D13#0nmos@538_poly-left##14 D13#0nmos@538_poly-left##15 9.953
R2027 D13#0nmos@538_poly-left##15 D13#0nmos@538_poly-left##16 9.953
R2028 D13#0nmos@538_poly-left##16 D13#0nmos@538_poly-left##17 9.953
R2029 D13#0nmos@538_poly-left##17 D13#1pin@1525_polysilicon-1 9.953
R2030 D13#1pin@1525_polysilicon-1 D13#1pin@1525_polysilicon-1##0 9.92
R2031 D13#1pin@1525_polysilicon-1##0 D13#1pin@1525_polysilicon-1##1 9.92
R2032 D13#1pin@1525_polysilicon-1##1 D13#1pin@1525_polysilicon-1##2 9.92
R2033 D13#1pin@1525_polysilicon-1##2 D13#1pin@1525_polysilicon-1##3 9.92
R2034 D13#1pin@1525_polysilicon-1##3 D13#2pmos@539_poly-right 9.92
R2035 D13#3contact@2747_metal-1-polysilicon-1 D13#3contact@2747_metal-1-polysilicon-1##0 8.525
R2036 D13#3contact@2747_metal-1-polysilicon-1##0 D13#3contact@2747_metal-1-polysilicon-1##1 8.525
R2037 D13#3contact@2747_metal-1-polysilicon-1##1 D13#3contact@2747_metal-1-polysilicon-1##2 8.525
R2038 D13#3contact@2747_metal-1-polysilicon-1##2 D13#1pin@1525_polysilicon-1 8.525
R2039 net@7212 net@7212##0 9.545
R2040 net@7212##0 net@7212##1 9.545
R2041 net@7212##1 net@7212##2 9.545
R2042 net@7212##2 net@7212##3 9.545
R2043 net@7212##3 net@7212##4 9.545
R2044 net@7212##4 net@7212##5 9.545
R2045 net@7212##5 net@7212##6 9.545
R2046 net@7212##6 net@7212##7 9.545
R2047 net@7212##7 net@7212##8 9.545
R2048 net@7212##8 net@7212##9 9.545
R2049 net@7212##9 net@7212##10 9.545
R2050 net@7212##10 net@7212##11 9.545
R2051 net@7212##11 net@7212##12 9.545
R2052 net@7212##12 net@7212##13 9.545
R2053 net@7212##13 net@7212##14 9.545
R2054 net@7212##14 net@7212##15 9.545
R2055 net@7212##15 net@7212##16 9.545
R2056 net@7212##16 net@7212##17 9.545
R2057 net@7212##17 net@7212#1contact@2757_metal-1-polysilicon-1 9.545
R2058 net@7212#1contact@2757_metal-1-polysilicon-1 net@7212#1contact@2757_metal-1-polysilicon-1##0 9.558
R2059 net@7212#1contact@2757_metal-1-polysilicon-1##0 net@7212#1contact@2757_metal-1-polysilicon-1##1 9.558
R2060 net@7212#1contact@2757_metal-1-polysilicon-1##1 net@7212#1contact@2757_metal-1-polysilicon-1##2 9.558
R2061 net@7212#1contact@2757_metal-1-polysilicon-1##2 net@7212#1contact@2757_metal-1-polysilicon-1##3 9.558
R2062 net@7212#1contact@2757_metal-1-polysilicon-1##3 net@7212#1contact@2757_metal-1-polysilicon-1##4 9.558
R2063 net@7212#1contact@2757_metal-1-polysilicon-1##4 net@7212#2nmos@539_poly-left 9.558
R2064 S0#54pmos@541_poly-right S0#54pmos@541_poly-right##0 9.743
R2065 S0#54pmos@541_poly-right##0 S0#54pmos@541_poly-right##1 9.743
R2066 S0#54pmos@541_poly-right##1 S0#54pmos@541_poly-right##2 9.743
R2067 S0#54pmos@541_poly-right##2 S0#54pmos@541_poly-right##3 9.743
R2068 S0#54pmos@541_poly-right##3 S0#54pmos@541_poly-right##4 9.743
R2069 S0#54pmos@541_poly-right##4 S0#54pmos@541_poly-right##5 9.743
R2070 S0#54pmos@541_poly-right##5 S0#54pmos@541_poly-right##6 9.743
R2071 S0#54pmos@541_poly-right##6 S0#54pmos@541_poly-right##7 9.743
R2072 S0#54pmos@541_poly-right##7 S0#54pmos@541_poly-right##8 9.743
R2073 S0#54pmos@541_poly-right##8 S0#54pmos@541_poly-right##9 9.743
R2074 S0#54pmos@541_poly-right##9 S0#54pmos@541_poly-right##10 9.743
R2075 S0#54pmos@541_poly-right##10 S0#54pmos@541_poly-right##11 9.743
R2076 S0#54pmos@541_poly-right##11 S0#54pmos@541_poly-right##12 9.743
R2077 S0#54pmos@541_poly-right##12 S0#54pmos@541_poly-right##13 9.743
R2078 S0#54pmos@541_poly-right##13 S0#54pmos@541_poly-right##14 9.743
R2079 S0#54pmos@541_poly-right##14 S0#54pmos@541_poly-right##15 9.743
R2080 S0#54pmos@541_poly-right##15 S0#54pmos@541_poly-right##16 9.743
R2081 S0#54pmos@541_poly-right##16 S0#54pmos@541_poly-right##17 9.743
R2082 S0#54pmos@541_poly-right##17 S0#54pmos@541_poly-right##18 9.743
R2083 S0#54pmos@541_poly-right##18 S0#54pmos@541_poly-right##19 9.743
R2084 S0#54pmos@541_poly-right##19 S0#55pin@1531_polysilicon-1 9.743
R2085 S0#55pin@1531_polysilicon-1 S0#55pin@1531_polysilicon-1##0 8.525
R2086 S0#55pin@1531_polysilicon-1##0 S0#55pin@1531_polysilicon-1##1 8.525
R2087 S0#55pin@1531_polysilicon-1##1 S0#55pin@1531_polysilicon-1##2 8.525
R2088 S0#55pin@1531_polysilicon-1##2 S0#56nmos@541_poly-left 8.525
R2089 S0#57contact@2759_metal-1-polysilicon-1 S0#57contact@2759_metal-1-polysilicon-1##0 5.425
R2090 S0#57contact@2759_metal-1-polysilicon-1##0 S0#55pin@1531_polysilicon-1 5.425
R2091 net@7201#10pmos@540_poly-right net@7201#11pin@1532_polysilicon-1 6.2
R2092 net@7201#11pin@1532_polysilicon-1 net@7201#11pin@1532_polysilicon-1##0 9.688
R2093 net@7201#11pin@1532_polysilicon-1##0 net@7201#11pin@1532_polysilicon-1##1 9.688
R2094 net@7201#11pin@1532_polysilicon-1##1 net@7201#11pin@1532_polysilicon-1##2 9.688
R2095 net@7201#11pin@1532_polysilicon-1##2 net@7201#11pin@1532_polysilicon-1##3 9.688
R2096 net@7201#11pin@1532_polysilicon-1##3 net@7201#11pin@1532_polysilicon-1##4 9.688
R2097 net@7201#11pin@1532_polysilicon-1##4 net@7201#11pin@1532_polysilicon-1##5 9.688
R2098 net@7201#11pin@1532_polysilicon-1##5 net@7201#11pin@1532_polysilicon-1##6 9.688
R2099 net@7201#11pin@1532_polysilicon-1##6 net@7201#11pin@1532_polysilicon-1##7 9.688
R2100 net@7201#11pin@1532_polysilicon-1##7 net@7201#11pin@1532_polysilicon-1##8 9.688
R2101 net@7201#11pin@1532_polysilicon-1##8 net@7201#11pin@1532_polysilicon-1##9 9.688
R2102 net@7201#11pin@1532_polysilicon-1##9 net@7201#11pin@1532_polysilicon-1##10 9.688
R2103 net@7201#11pin@1532_polysilicon-1##10 net@7201#11pin@1532_polysilicon-1##11 9.688
R2104 net@7201#11pin@1532_polysilicon-1##11 net@7201#11pin@1532_polysilicon-1##12 9.688
R2105 net@7201#11pin@1532_polysilicon-1##12 net@7201#11pin@1532_polysilicon-1##13 9.688
R2106 net@7201#11pin@1532_polysilicon-1##13 net@7201#11pin@1532_polysilicon-1##14 9.688
R2107 net@7201#11pin@1532_polysilicon-1##14 net@7201#11pin@1532_polysilicon-1##15 9.688
R2108 net@7201#11pin@1532_polysilicon-1##15 net@7201#11pin@1532_polysilicon-1##16 9.688
R2109 net@7201#11pin@1532_polysilicon-1##16 net@7201#11pin@1532_polysilicon-1##17 9.688
R2110 net@7201#11pin@1532_polysilicon-1##17 net@7201#11pin@1532_polysilicon-1##18 9.688
R2111 net@7201#11pin@1532_polysilicon-1##18 net@7201#11pin@1532_polysilicon-1##19 9.688
R2112 net@7201#11pin@1532_polysilicon-1##19 net@7201#11pin@1532_polysilicon-1##20 9.688
R2113 net@7201#11pin@1532_polysilicon-1##20 net@7201#11pin@1532_polysilicon-1##21 9.688
R2114 net@7201#11pin@1532_polysilicon-1##21 net@7201#11pin@1532_polysilicon-1##22 9.688
R2115 net@7201#11pin@1532_polysilicon-1##22 net@7201#12nmos@540_poly-right 9.688
R2116 net@7201 net@7201##0 8.68
R2117 net@7201##0 net@7201##1 8.68
R2118 net@7201##1 net@7201##2 8.68
R2119 net@7201##2 net@7201##3 8.68
R2120 net@7201##3 net@7201#11pin@1532_polysilicon-1 8.68
R2121 net@7230 net@7230 0
R2122 D14#0nmos@542_poly-left D14#0nmos@542_poly-left##0 9.665
R2123 D14#0nmos@542_poly-left##0 D14#0nmos@542_poly-left##1 9.665
R2124 D14#0nmos@542_poly-left##1 D14#0nmos@542_poly-left##2 9.665
R2125 D14#0nmos@542_poly-left##2 D14#0nmos@542_poly-left##3 9.665
R2126 D14#0nmos@542_poly-left##3 D14#0nmos@542_poly-left##4 9.665
R2127 D14#0nmos@542_poly-left##4 D14#0nmos@542_poly-left##5 9.665
R2128 D14#0nmos@542_poly-left##5 D14#0nmos@542_poly-left##6 9.665
R2129 D14#0nmos@542_poly-left##6 D14#0nmos@542_poly-left##7 9.665
R2130 D14#0nmos@542_poly-left##7 D14#0nmos@542_poly-left##8 9.665
R2131 D14#0nmos@542_poly-left##8 D14#0nmos@542_poly-left##9 9.665
R2132 D14#0nmos@542_poly-left##9 D14#0nmos@542_poly-left##10 9.665
R2133 D14#0nmos@542_poly-left##10 D14#0nmos@542_poly-left##11 9.665
R2134 D14#0nmos@542_poly-left##11 D14#0nmos@542_poly-left##12 9.665
R2135 D14#0nmos@542_poly-left##12 D14#0nmos@542_poly-left##13 9.665
R2136 D14#0nmos@542_poly-left##13 D14#0nmos@542_poly-left##14 9.665
R2137 D14#0nmos@542_poly-left##14 D14#0nmos@542_poly-left##15 9.665
R2138 D14#0nmos@542_poly-left##15 D14#1pin@1533_polysilicon-1 9.665
R2139 D14#1pin@1533_polysilicon-1 D14#1pin@1533_polysilicon-1##0 9.3
R2140 D14#1pin@1533_polysilicon-1##0 D14#1pin@1533_polysilicon-1##1 9.3
R2141 D14#1pin@1533_polysilicon-1##1 D14#1pin@1533_polysilicon-1##2 9.3
R2142 D14#1pin@1533_polysilicon-1##2 D14#1pin@1533_polysilicon-1##3 9.3
R2143 D14#1pin@1533_polysilicon-1##3 D14#1pin@1533_polysilicon-1##4 9.3
R2144 D14#1pin@1533_polysilicon-1##4 D14#1pin@1533_polysilicon-1##5 9.3
R2145 D14#1pin@1533_polysilicon-1##5 D14#1pin@1533_polysilicon-1##6 9.3
R2146 D14#1pin@1533_polysilicon-1##6 D14#2pmos@543_poly-right 9.3
R2147 D14#3contact@2763_metal-1-polysilicon-1 D14#3contact@2763_metal-1-polysilicon-1##0 9.688
R2148 D14#3contact@2763_metal-1-polysilicon-1##0 D14#3contact@2763_metal-1-polysilicon-1##1 9.688
R2149 D14#3contact@2763_metal-1-polysilicon-1##1 D14#3contact@2763_metal-1-polysilicon-1##2 9.688
R2150 D14#3contact@2763_metal-1-polysilicon-1##2 D14#1pin@1533_polysilicon-1 9.688
R2151 S1#51pmos@542_poly-right S1#51pmos@542_poly-right##0 9.3
R2152 S1#51pmos@542_poly-right##0 S1#51pmos@542_poly-right##1 9.3
R2153 S1#51pmos@542_poly-right##1 S1#51pmos@542_poly-right##2 9.3
R2154 S1#51pmos@542_poly-right##2 S1#51pmos@542_poly-right##3 9.3
R2155 S1#51pmos@542_poly-right##3 S1#51pmos@542_poly-right##4 9.3
R2156 S1#51pmos@542_poly-right##4 S1#51pmos@542_poly-right##5 9.3
R2157 S1#51pmos@542_poly-right##5 S1#51pmos@542_poly-right##6 9.3
R2158 S1#51pmos@542_poly-right##6 S1#51pmos@542_poly-right##7 9.3
R2159 S1#51pmos@542_poly-right##7 S1#51pmos@542_poly-right##8 9.3
R2160 S1#51pmos@542_poly-right##8 S1 9.3
R2161 S1 S1##0 9.713
R2162 S1##0 S1##1 9.713
R2163 S1##1 S1##2 9.713
R2164 S1##2 S1##3 9.713
R2165 S1##3 S1##4 9.713
R2166 S1##4 S1##5 9.713
R2167 S1##5 S1##6 9.713
R2168 S1##6 S1##7 9.713
R2169 S1##7 S1##8 9.713
R2170 S1##8 S1##9 9.713
R2171 S1##9 S1##10 9.713
R2172 S1##10 S1##11 9.713
R2173 S1##11 S1##12 9.713
R2174 S1##12 S1##13 9.713
R2175 S1##13 S1#53nmos@543_poly-left 9.713
R2176 net@7257 net@7257##0 9.817
R2177 net@7257##0 net@7257##1 9.817
R2178 net@7257##1 net@7257##2 9.817
R2179 net@7257##2 net@7257##3 9.817
R2180 net@7257##3 net@7257##4 9.817
R2181 net@7257##4 net@7257##5 9.817
R2182 net@7257##5 net@7257##6 9.817
R2183 net@7257##6 net@7257##7 9.817
R2184 net@7257##7 net@7257##8 9.817
R2185 net@7257##8 net@7257##9 9.817
R2186 net@7257##9 net@7257##10 9.817
R2187 net@7257##10 net@7257#1pin@1539_polysilicon-1 9.817
R2188 net@7257#1pin@1539_polysilicon-1 net@7257#1pin@1539_polysilicon-1##0 9.3
R2189 net@7257#1pin@1539_polysilicon-1##0 net@7257#1pin@1539_polysilicon-1##1 9.3
R2190 net@7257#1pin@1539_polysilicon-1##1 net@7257#1pin@1539_polysilicon-1##2 9.3
R2191 net@7257#1pin@1539_polysilicon-1##2 net@7257#1pin@1539_polysilicon-1##3 9.3
R2192 net@7257#1pin@1539_polysilicon-1##3 net@7257#1pin@1539_polysilicon-1##4 9.3
R2193 net@7257#1pin@1539_polysilicon-1##4 net@7257#1pin@1539_polysilicon-1##5 9.3
R2194 net@7257#1pin@1539_polysilicon-1##5 net@7257#1pin@1539_polysilicon-1##6 9.3
R2195 net@7257#1pin@1539_polysilicon-1##6 net@7257#1pin@1539_polysilicon-1##7 9.3
R2196 net@7257#1pin@1539_polysilicon-1##7 net@7257#1pin@1539_polysilicon-1##8 9.3
R2197 net@7257#1pin@1539_polysilicon-1##8 net@7257#1pin@1539_polysilicon-1##9 9.3
R2198 net@7257#1pin@1539_polysilicon-1##9 net@7257#1pin@1539_polysilicon-1##10 9.3
R2199 net@7257#1pin@1539_polysilicon-1##10 net@7257#1pin@1539_polysilicon-1##11 9.3
R2200 net@7257#1pin@1539_polysilicon-1##11 net@7257#2nmos@545_poly-left 9.3
R2201 net@7257#3contact@2775_metal-1-polysilicon-1 net@7257#3contact@2775_metal-1-polysilicon-1##0 5.425
R2202 net@7257#3contact@2775_metal-1-polysilicon-1##0 net@7257#1pin@1539_polysilicon-1 5.425
R2203 net@7237#10pmos@544_poly-right net@7237#11pin@1540_polysilicon-1 6.2
R2204 net@7237#11pin@1540_polysilicon-1 net@7237#11pin@1540_polysilicon-1##0 9.688
R2205 net@7237#11pin@1540_polysilicon-1##0 net@7237#11pin@1540_polysilicon-1##1 9.688
R2206 net@7237#11pin@1540_polysilicon-1##1 net@7237#11pin@1540_polysilicon-1##2 9.688
R2207 net@7237#11pin@1540_polysilicon-1##2 net@7237#11pin@1540_polysilicon-1##3 9.688
R2208 net@7237#11pin@1540_polysilicon-1##3 net@7237#11pin@1540_polysilicon-1##4 9.688
R2209 net@7237#11pin@1540_polysilicon-1##4 net@7237#11pin@1540_polysilicon-1##5 9.688
R2210 net@7237#11pin@1540_polysilicon-1##5 net@7237#11pin@1540_polysilicon-1##6 9.688
R2211 net@7237#11pin@1540_polysilicon-1##6 net@7237#11pin@1540_polysilicon-1##7 9.688
R2212 net@7237#11pin@1540_polysilicon-1##7 net@7237#11pin@1540_polysilicon-1##8 9.688
R2213 net@7237#11pin@1540_polysilicon-1##8 net@7237#11pin@1540_polysilicon-1##9 9.688
R2214 net@7237#11pin@1540_polysilicon-1##9 net@7237#11pin@1540_polysilicon-1##10 9.688
R2215 net@7237#11pin@1540_polysilicon-1##10 net@7237#11pin@1540_polysilicon-1##11 9.688
R2216 net@7237#11pin@1540_polysilicon-1##11 net@7237#11pin@1540_polysilicon-1##12 9.688
R2217 net@7237#11pin@1540_polysilicon-1##12 net@7237#11pin@1540_polysilicon-1##13 9.688
R2218 net@7237#11pin@1540_polysilicon-1##13 net@7237#11pin@1540_polysilicon-1##14 9.688
R2219 net@7237#11pin@1540_polysilicon-1##14 net@7237#11pin@1540_polysilicon-1##15 9.688
R2220 net@7237#11pin@1540_polysilicon-1##15 net@7237#11pin@1540_polysilicon-1##16 9.688
R2221 net@7237#11pin@1540_polysilicon-1##16 net@7237#11pin@1540_polysilicon-1##17 9.688
R2222 net@7237#11pin@1540_polysilicon-1##17 net@7237#11pin@1540_polysilicon-1##18 9.688
R2223 net@7237#11pin@1540_polysilicon-1##18 net@7237#11pin@1540_polysilicon-1##19 9.688
R2224 net@7237#11pin@1540_polysilicon-1##19 net@7237#11pin@1540_polysilicon-1##20 9.688
R2225 net@7237#11pin@1540_polysilicon-1##20 net@7237#11pin@1540_polysilicon-1##21 9.688
R2226 net@7237#11pin@1540_polysilicon-1##21 net@7237#11pin@1540_polysilicon-1##22 9.688
R2227 net@7237#11pin@1540_polysilicon-1##22 net@7237#12nmos@544_poly-right 9.688
R2228 net@7237 net@7237##0 8.68
R2229 net@7237##0 net@7237##1 8.68
R2230 net@7237##1 net@7237##2 8.68
R2231 net@7237##2 net@7237##3 8.68
R2232 net@7237##3 net@7237#11pin@1540_polysilicon-1 8.68
R2233 net@7266 net@7266 0
R2234 net@7207#11pmos@530_poly-right net@7207#11pmos@530_poly-right##0 9.743
R2235 net@7207#11pmos@530_poly-right##0 net@7207#11pmos@530_poly-right##1 9.743
R2236 net@7207#11pmos@530_poly-right##1 net@7207#11pmos@530_poly-right##2 9.743
R2237 net@7207#11pmos@530_poly-right##2 net@7207#11pmos@530_poly-right##3 9.743
R2238 net@7207#11pmos@530_poly-right##3 net@7207#11pmos@530_poly-right##4 9.743
R2239 net@7207#11pmos@530_poly-right##4 net@7207#11pmos@530_poly-right##5 9.743
R2240 net@7207#11pmos@530_poly-right##5 net@7207#11pmos@530_poly-right##6 9.743
R2241 net@7207#11pmos@530_poly-right##6 net@7207#11pmos@530_poly-right##7 9.743
R2242 net@7207#11pmos@530_poly-right##7 net@7207#11pmos@530_poly-right##8 9.743
R2243 net@7207#11pmos@530_poly-right##8 net@7207#11pmos@530_poly-right##9 9.743
R2244 net@7207#11pmos@530_poly-right##9 net@7207#11pmos@530_poly-right##10 9.743
R2245 net@7207#11pmos@530_poly-right##10 net@7207#11pmos@530_poly-right##11 9.743
R2246 net@7207#11pmos@530_poly-right##11 net@7207#11pmos@530_poly-right##12 9.743
R2247 net@7207#11pmos@530_poly-right##12 net@7207#11pmos@530_poly-right##13 9.743
R2248 net@7207#11pmos@530_poly-right##13 net@7207#11pmos@530_poly-right##14 9.743
R2249 net@7207#11pmos@530_poly-right##14 net@7207#11pmos@530_poly-right##15 9.743
R2250 net@7207#11pmos@530_poly-right##15 net@7207#11pmos@530_poly-right##16 9.743
R2251 net@7207#11pmos@530_poly-right##16 net@7207#11pmos@530_poly-right##17 9.743
R2252 net@7207#11pmos@530_poly-right##17 net@7207#11pmos@530_poly-right##18 9.743
R2253 net@7207#11pmos@530_poly-right##18 net@7207#11pmos@530_poly-right##19 9.743
R2254 net@7207#11pmos@530_poly-right##19 net@7207#12pin@1511_polysilicon-1 9.743
R2255 net@7207#12pin@1511_polysilicon-1 net@7207#12pin@1511_polysilicon-1##0 8.525
R2256 net@7207#12pin@1511_polysilicon-1##0 net@7207#12pin@1511_polysilicon-1##1 8.525
R2257 net@7207#12pin@1511_polysilicon-1##1 net@7207#12pin@1511_polysilicon-1##2 8.525
R2258 net@7207#12pin@1511_polysilicon-1##2 net@7207#13nmos@531_poly-right 8.525
R2259 net@7207 net@7207##0 9.042
R2260 net@7207##0 net@7207##1 9.042
R2261 net@7207##1 net@7207##2 9.042
R2262 net@7207##2 net@7207##3 9.042
R2263 net@7207##3 net@7207##4 9.042
R2264 net@7207##4 net@7207#12pin@1511_polysilicon-1 9.042
R2265 net@7292 net@7292##0 9.704
R2266 net@7292##0 net@7292##1 9.704
R2267 net@7292##1 net@7292##2 9.704
R2268 net@7292##2 net@7292##3 9.704
R2269 net@7292##3 net@7292##4 9.704
R2270 net@7292##4 net@7292##5 9.704
R2271 net@7292##5 net@7292##6 9.704
R2272 net@7292##6 net@7292##7 9.704
R2273 net@7292##7 net@7292##8 9.704
R2274 net@7292##8 net@7292##9 9.704
R2275 net@7292##9 net@7292##10 9.704
R2276 net@7292##10 net@7292##11 9.704
R2277 net@7292##11 net@7292##12 9.704
R2278 net@7292##12 net@7292##13 9.704
R2279 net@7292##13 net@7292##14 9.704
R2280 net@7292##14 net@7292##15 9.704
R2281 net@7292##15 net@7292##16 9.704
R2282 net@7292##16 net@7292##17 9.704
R2283 net@7292##17 net@7292##18 9.704
R2284 net@7292##18 net@7292##19 9.704
R2285 net@7292##19 net@7292##20 9.704
R2286 net@7292##20 net@7292##21 9.704
R2287 net@7292##21 net@7292#1pin@1513_polysilicon-1 9.704
R2288 net@7292#1pin@1513_polysilicon-1 net@7292#1pin@1513_polysilicon-1##0 7.75
R2289 net@7292#1pin@1513_polysilicon-1##0 net@7292#2pmos@531_poly-right 7.75
R2290 net@7292#3contact@2713_metal-1-polysilicon-1 net@7292#3contact@2713_metal-1-polysilicon-1##0 9.3
R2291 net@7292#3contact@2713_metal-1-polysilicon-1##0 net@7292#3contact@2713_metal-1-polysilicon-1##1 9.3
R2292 net@7292#3contact@2713_metal-1-polysilicon-1##1 net@7292#3contact@2713_metal-1-polysilicon-1##2 9.3
R2293 net@7292#3contact@2713_metal-1-polysilicon-1##2 net@7292#3contact@2713_metal-1-polysilicon-1##3 9.3
R2294 net@7292#3contact@2713_metal-1-polysilicon-1##3 net@7292#1pin@1513_polysilicon-1 9.3
R2295 net@7194#4pmos@529_poly-right net@7194#4pmos@529_poly-right##0 8.783
R2296 net@7194#4pmos@529_poly-right##0 net@7194#4pmos@529_poly-right##1 8.783
R2297 net@7194#4pmos@529_poly-right##1 net@7194#4pmos@529_poly-right##2 8.783
R2298 net@7194#4pmos@529_poly-right##2 net@7194#4pmos@529_poly-right##3 8.783
R2299 net@7194#4pmos@529_poly-right##3 net@7194#4pmos@529_poly-right##4 8.783
R2300 net@7194#4pmos@529_poly-right##4 net@7194 8.783
R2301 net@7194 net@7194##0 9.789
R2302 net@7194##0 net@7194##1 9.789
R2303 net@7194##1 net@7194##2 9.789
R2304 net@7194##2 net@7194##3 9.789
R2305 net@7194##3 net@7194##4 9.789
R2306 net@7194##4 net@7194##5 9.789
R2307 net@7194##5 net@7194##6 9.789
R2308 net@7194##6 net@7194##7 9.789
R2309 net@7194##7 net@7194##8 9.789
R2310 net@7194##8 net@7194##9 9.789
R2311 net@7194##9 net@7194##10 9.789
R2312 net@7194##10 net@7194##11 9.789
R2313 net@7194##11 net@7194##12 9.789
R2314 net@7194##12 net@7194##13 9.789
R2315 net@7194##13 net@7194##14 9.789
R2316 net@7194##14 net@7194##15 9.789
R2317 net@7194##15 net@7194##16 9.789
R2318 net@7194##16 net@7194##17 9.789
R2319 net@7194##17 net@7194#6nmos@530_poly-left 9.789
R2320 net@7230#4nmos@532_poly-left net@7230#4nmos@532_poly-left##0 9.756
R2321 net@7230#4nmos@532_poly-left##0 net@7230#4nmos@532_poly-left##1 9.756
R2322 net@7230#4nmos@532_poly-left##1 net@7230#4nmos@532_poly-left##2 9.756
R2323 net@7230#4nmos@532_poly-left##2 net@7230#4nmos@532_poly-left##3 9.756
R2324 net@7230#4nmos@532_poly-left##3 net@7230#4nmos@532_poly-left##4 9.756
R2325 net@7230#4nmos@532_poly-left##4 net@7230#4nmos@532_poly-left##5 9.756
R2326 net@7230#4nmos@532_poly-left##5 net@7230#4nmos@532_poly-left##6 9.756
R2327 net@7230#4nmos@532_poly-left##6 net@7230#4nmos@532_poly-left##7 9.756
R2328 net@7230#4nmos@532_poly-left##7 net@7230#4nmos@532_poly-left##8 9.756
R2329 net@7230#4nmos@532_poly-left##8 net@7230#4nmos@532_poly-left##9 9.756
R2330 net@7230#4nmos@532_poly-left##9 net@7230#4nmos@532_poly-left##10 9.756
R2331 net@7230#4nmos@532_poly-left##10 net@7230#4nmos@532_poly-left##11 9.756
R2332 net@7230#4nmos@532_poly-left##11 net@7230#4nmos@532_poly-left##12 9.756
R2333 net@7230#4nmos@532_poly-left##12 net@7230#4nmos@532_poly-left##13 9.756
R2334 net@7230#4nmos@532_poly-left##13 net@7230#4nmos@532_poly-left##14 9.756
R2335 net@7230#4nmos@532_poly-left##14 net@7230#4nmos@532_poly-left##15 9.756
R2336 net@7230#4nmos@532_poly-left##15 net@7230#5contact@2727_metal-1-polysilicon-1 9.756
R2337 net@7230#5contact@2727_metal-1-polysilicon-1 net@7230#5contact@2727_metal-1-polysilicon-1##0 9.106
R2338 net@7230#5contact@2727_metal-1-polysilicon-1##0 net@7230#5contact@2727_metal-1-polysilicon-1##1 9.106
R2339 net@7230#5contact@2727_metal-1-polysilicon-1##1 net@7230#5contact@2727_metal-1-polysilicon-1##2 9.106
R2340 net@7230#5contact@2727_metal-1-polysilicon-1##2 net@7230#5contact@2727_metal-1-polysilicon-1##3 9.106
R2341 net@7230#5contact@2727_metal-1-polysilicon-1##3 net@7230#5contact@2727_metal-1-polysilicon-1##4 9.106
R2342 net@7230#5contact@2727_metal-1-polysilicon-1##4 net@7230#5contact@2727_metal-1-polysilicon-1##5 9.106
R2343 net@7230#5contact@2727_metal-1-polysilicon-1##5 net@7230#5contact@2727_metal-1-polysilicon-1##6 9.106
R2344 net@7230#5contact@2727_metal-1-polysilicon-1##6 net@7230#6pmos@533_poly-right 9.106
R2345 net@7301 net@7301##0 9.574
R2346 net@7301##0 net@7301##1 9.574
R2347 net@7301##1 net@7301##2 9.574
R2348 net@7301##2 net@7301##3 9.574
R2349 net@7301##3 net@7301##4 9.574
R2350 net@7301##4 net@7301##5 9.574
R2351 net@7301##5 net@7301##6 9.574
R2352 net@7301##6 net@7301##7 9.574
R2353 net@7301##7 net@7301##8 9.574
R2354 net@7301##8 net@7301##9 9.574
R2355 net@7301##9 net@7301##10 9.574
R2356 net@7301##10 net@7301##11 9.574
R2357 net@7301##11 net@7301##12 9.574
R2358 net@7301##12 net@7301##13 9.574
R2359 net@7301##13 net@7301##14 9.574
R2360 net@7301##14 net@7301##15 9.574
R2361 net@7301##15 net@7301#1contact@2728_metal-1-polysilicon-1 9.574
R2362 net@7301#1contact@2728_metal-1-polysilicon-1 net@7301#1contact@2728_metal-1-polysilicon-1##0 9.494
R2363 net@7301#1contact@2728_metal-1-polysilicon-1##0 net@7301#1contact@2728_metal-1-polysilicon-1##1 9.494
R2364 net@7301#1contact@2728_metal-1-polysilicon-1##1 net@7301#1contact@2728_metal-1-polysilicon-1##2 9.494
R2365 net@7301#1contact@2728_metal-1-polysilicon-1##2 net@7301#1contact@2728_metal-1-polysilicon-1##3 9.494
R2366 net@7301#1contact@2728_metal-1-polysilicon-1##3 net@7301#1contact@2728_metal-1-polysilicon-1##4 9.494
R2367 net@7301#1contact@2728_metal-1-polysilicon-1##4 net@7301#1contact@2728_metal-1-polysilicon-1##5 9.494
R2368 net@7301#1contact@2728_metal-1-polysilicon-1##5 net@7301#1contact@2728_metal-1-polysilicon-1##6 9.494
R2369 net@7301#1contact@2728_metal-1-polysilicon-1##6 net@7301#2nmos@533_poly-left 9.494
R2370 net@7292#3contact@2713_metal-1-polysilicon-1 net@7292#3contact@2713_metal-1-polysilicon-1 0
R2371 net@7317 net@7317#1pin@1547_polysilicon-1 7.75
R2372 net@7317#1pin@1547_polysilicon-1 net@7317#1pin@1547_polysilicon-1##0 9.623
R2373 net@7317#1pin@1547_polysilicon-1##0 net@7317#1pin@1547_polysilicon-1##1 9.623
R2374 net@7317#1pin@1547_polysilicon-1##1 net@7317#1pin@1547_polysilicon-1##2 9.623
R2375 net@7317#1pin@1547_polysilicon-1##2 net@7317#1pin@1547_polysilicon-1##3 9.623
R2376 net@7317#1pin@1547_polysilicon-1##3 net@7317#1pin@1547_polysilicon-1##4 9.623
R2377 net@7317#1pin@1547_polysilicon-1##4 net@7317#1pin@1547_polysilicon-1##5 9.623
R2378 net@7317#1pin@1547_polysilicon-1##5 net@7317#1pin@1547_polysilicon-1##6 9.623
R2379 net@7317#1pin@1547_polysilicon-1##6 net@7317#1pin@1547_polysilicon-1##7 9.623
R2380 net@7317#1pin@1547_polysilicon-1##7 net@7317#1pin@1547_polysilicon-1##8 9.623
R2381 net@7317#1pin@1547_polysilicon-1##8 net@7317#1pin@1547_polysilicon-1##9 9.623
R2382 net@7317#1pin@1547_polysilicon-1##9 net@7317#1pin@1547_polysilicon-1##10 9.623
R2383 net@7317#1pin@1547_polysilicon-1##10 net@7317#1pin@1547_polysilicon-1##11 9.623
R2384 net@7317#1pin@1547_polysilicon-1##11 net@7317#1pin@1547_polysilicon-1##12 9.623
R2385 net@7317#1pin@1547_polysilicon-1##12 net@7317#1pin@1547_polysilicon-1##13 9.623
R2386 net@7317#1pin@1547_polysilicon-1##13 net@7317#1pin@1547_polysilicon-1##14 9.623
R2387 net@7317#1pin@1547_polysilicon-1##14 net@7317#1pin@1547_polysilicon-1##15 9.623
R2388 net@7317#1pin@1547_polysilicon-1##15 net@7317#1pin@1547_polysilicon-1##16 9.623
R2389 net@7317#1pin@1547_polysilicon-1##16 net@7317#1pin@1547_polysilicon-1##17 9.623
R2390 net@7317#1pin@1547_polysilicon-1##17 net@7317#1pin@1547_polysilicon-1##18 9.623
R2391 net@7317#1pin@1547_polysilicon-1##18 net@7317#1pin@1547_polysilicon-1##19 9.623
R2392 net@7317#1pin@1547_polysilicon-1##19 net@7317#1pin@1547_polysilicon-1##20 9.623
R2393 net@7317#1pin@1547_polysilicon-1##20 net@7317#1pin@1547_polysilicon-1##21 9.623
R2394 net@7317#1pin@1547_polysilicon-1##21 net@7317#1pin@1547_polysilicon-1##22 9.623
R2395 net@7317#1pin@1547_polysilicon-1##22 net@7317#2nmos@548_poly-right 9.623
R2396 net@7317#3contact@2792_metal-1-polysilicon-1 net@7317#3contact@2792_metal-1-polysilicon-1##0 8.68
R2397 net@7317#3contact@2792_metal-1-polysilicon-1##0 net@7317#3contact@2792_metal-1-polysilicon-1##1 8.68
R2398 net@7317#3contact@2792_metal-1-polysilicon-1##1 net@7317#3contact@2792_metal-1-polysilicon-1##2 8.68
R2399 net@7317#3contact@2792_metal-1-polysilicon-1##2 net@7317#3contact@2792_metal-1-polysilicon-1##3 8.68
R2400 net@7317#3contact@2792_metal-1-polysilicon-1##3 net@7317#1pin@1547_polysilicon-1 8.68
R2401 net@7301#4contact@2784_metal-1-n-act net@7301#4contact@2784_metal-1-n-act 0
R2402 S1#55pmos@546_poly-right S1#55pmos@546_poly-right##0 9.482
R2403 S1#55pmos@546_poly-right##0 S1#55pmos@546_poly-right##1 9.482
R2404 S1#55pmos@546_poly-right##1 S1#55pmos@546_poly-right##2 9.482
R2405 S1#55pmos@546_poly-right##2 S1#55pmos@546_poly-right##3 9.482
R2406 S1#55pmos@546_poly-right##3 S1#55pmos@546_poly-right##4 9.482
R2407 S1#55pmos@546_poly-right##4 S1#55pmos@546_poly-right##5 9.482
R2408 S1#55pmos@546_poly-right##5 S1#55pmos@546_poly-right##6 9.482
R2409 S1#55pmos@546_poly-right##6 S1#55pmos@546_poly-right##7 9.482
R2410 S1#55pmos@546_poly-right##7 S1#55pmos@546_poly-right##8 9.482
R2411 S1#55pmos@546_poly-right##8 S1#55pmos@546_poly-right##9 9.482
R2412 S1#55pmos@546_poly-right##9 S1#55pmos@546_poly-right##10 9.482
R2413 S1#55pmos@546_poly-right##10 S1#55pmos@546_poly-right##11 9.482
R2414 S1#55pmos@546_poly-right##11 S1#55pmos@546_poly-right##12 9.482
R2415 S1#55pmos@546_poly-right##12 S1#55pmos@546_poly-right##13 9.482
R2416 S1#55pmos@546_poly-right##13 S1#55pmos@546_poly-right##14 9.482
R2417 S1#55pmos@546_poly-right##14 S1#55pmos@546_poly-right##15 9.482
R2418 S1#55pmos@546_poly-right##15 S1 9.482
R2419 S1 S1##0 9.688
R2420 S1##0 S1##1 9.688
R2421 S1##1 S1##2 9.688
R2422 S1##2 S1##3 9.688
R2423 S1##3 S1##4 9.688
R2424 S1##4 S1##5 9.688
R2425 S1##5 S1##6 9.688
R2426 S1##6 S1#57nmos@547_poly-left 9.688
R2427 S0#59pmos@549_poly-right S0#59pmos@549_poly-right##0 9.871
R2428 S0#59pmos@549_poly-right##0 S0#59pmos@549_poly-right##1 9.871
R2429 S0#59pmos@549_poly-right##1 S0#59pmos@549_poly-right##2 9.871
R2430 S0#59pmos@549_poly-right##2 S0#59pmos@549_poly-right##3 9.871
R2431 S0#59pmos@549_poly-right##3 S0#59pmos@549_poly-right##4 9.871
R2432 S0#59pmos@549_poly-right##4 S0#59pmos@549_poly-right##5 9.871
R2433 S0#59pmos@549_poly-right##5 S0#59pmos@549_poly-right##6 9.871
R2434 S0#59pmos@549_poly-right##6 S0#59pmos@549_poly-right##7 9.871
R2435 S0#59pmos@549_poly-right##7 S0#59pmos@549_poly-right##8 9.871
R2436 S0#59pmos@549_poly-right##8 S0#59pmos@549_poly-right##9 9.871
R2437 S0#59pmos@549_poly-right##9 S0#59pmos@549_poly-right##10 9.871
R2438 S0#59pmos@549_poly-right##10 S0#59pmos@549_poly-right##11 9.871
R2439 S0#59pmos@549_poly-right##11 S0#59pmos@549_poly-right##12 9.871
R2440 S0#59pmos@549_poly-right##12 S0#59pmos@549_poly-right##13 9.871
R2441 S0#59pmos@549_poly-right##13 S0#59pmos@549_poly-right##14 9.871
R2442 S0#59pmos@549_poly-right##14 S0#59pmos@549_poly-right##15 9.871
R2443 S0#59pmos@549_poly-right##15 S0#59pmos@549_poly-right##16 9.871
R2444 S0#59pmos@549_poly-right##16 S0#59pmos@549_poly-right##17 9.871
R2445 S0#59pmos@549_poly-right##17 S0#60pin@1546_polysilicon-1 9.871
R2446 S0#60pin@1546_polysilicon-1 S0#60pin@1546_polysilicon-1##0 8.525
R2447 S0#60pin@1546_polysilicon-1##0 S0#60pin@1546_polysilicon-1##1 8.525
R2448 S0#60pin@1546_polysilicon-1##1 S0#60pin@1546_polysilicon-1##2 8.525
R2449 S0#60pin@1546_polysilicon-1##2 S0#60pin@1546_polysilicon-1##3 8.525
R2450 S0#60pin@1546_polysilicon-1##3 S0#60pin@1546_polysilicon-1##4 8.525
R2451 S0#60pin@1546_polysilicon-1##4 S0#61nmos@549_poly-left 8.525
R2452 S0 S0##0 5.425
R2453 S0##0 S0#60pin@1546_polysilicon-1 5.425
R2454 net@7212#3contact@2794_metal-1-p-act net@7212#3contact@2794_metal-1-p-act 0
R2455 S0#64pmos@551_poly-right S0#64pmos@551_poly-right##0 9.817
R2456 S0#64pmos@551_poly-right##0 S0#64pmos@551_poly-right##1 9.817
R2457 S0#64pmos@551_poly-right##1 S0#64pmos@551_poly-right##2 9.817
R2458 S0#64pmos@551_poly-right##2 S0#64pmos@551_poly-right##3 9.817
R2459 S0#64pmos@551_poly-right##3 S0#64pmos@551_poly-right##4 9.817
R2460 S0#64pmos@551_poly-right##4 S0#64pmos@551_poly-right##5 9.817
R2461 S0#64pmos@551_poly-right##5 S0#64pmos@551_poly-right##6 9.817
R2462 S0#64pmos@551_poly-right##6 S0#64pmos@551_poly-right##7 9.817
R2463 S0#64pmos@551_poly-right##7 S0#64pmos@551_poly-right##8 9.817
R2464 S0#64pmos@551_poly-right##8 S0#64pmos@551_poly-right##9 9.817
R2465 S0#64pmos@551_poly-right##9 S0#64pmos@551_poly-right##10 9.817
R2466 S0#64pmos@551_poly-right##10 S0#64pmos@551_poly-right##11 9.817
R2467 S0#64pmos@551_poly-right##11 S0#64pmos@551_poly-right##12 9.817
R2468 S0#64pmos@551_poly-right##12 S0#64pmos@551_poly-right##13 9.817
R2469 S0#64pmos@551_poly-right##13 S0#64pmos@551_poly-right##14 9.817
R2470 S0#64pmos@551_poly-right##14 S0#64pmos@551_poly-right##15 9.817
R2471 S0#64pmos@551_poly-right##15 S0#64pmos@551_poly-right##16 9.817
R2472 S0#64pmos@551_poly-right##16 S0#64pmos@551_poly-right##17 9.817
R2473 S0#64pmos@551_poly-right##17 S0#64pmos@551_poly-right##18 9.817
R2474 S0#64pmos@551_poly-right##18 S0#64pmos@551_poly-right##19 9.817
R2475 S0#64pmos@551_poly-right##19 S0#65pin@1548_polysilicon-1 9.817
R2476 S0#65pin@1548_polysilicon-1 S0#65pin@1548_polysilicon-1##0 8.138
R2477 S0#65pin@1548_polysilicon-1##0 S0#65pin@1548_polysilicon-1##1 8.138
R2478 S0#65pin@1548_polysilicon-1##1 S0#65pin@1548_polysilicon-1##2 8.138
R2479 S0#65pin@1548_polysilicon-1##2 S0#66nmos@551_poly-right 8.138
R2480 S0 S0##0 9.756
R2481 S0##0 S0##1 9.756
R2482 S0##1 S0##2 9.756
R2483 S0##2 S0##3 9.756
R2484 S0##3 S0##4 9.756
R2485 S0##4 S0##5 9.756
R2486 S0##5 S0##6 9.756
R2487 S0##6 S0##7 9.756
R2488 S0##7 S0##8 9.756
R2489 S0##8 S0##9 9.756
R2490 S0##9 S0##10 9.756
R2491 S0##10 S0##11 9.756
R2492 S0##11 S0##12 9.756
R2493 S0##12 S0##13 9.756
R2494 S0##13 S0##14 9.756
R2495 S0##14 S0##15 9.756
R2496 S0##15 S0#65pin@1548_polysilicon-1 9.756
R2497 net@7257#3contact@2775_metal-1-polysilicon-1 net@7257#3contact@2775_metal-1-polysilicon-1 0
R2498 S1#62pmos@550_poly-right S1#62pmos@550_poly-right##0 9.623
R2499 S1#62pmos@550_poly-right##0 S1#62pmos@550_poly-right##1 9.623
R2500 S1#62pmos@550_poly-right##1 S1#62pmos@550_poly-right##2 9.623
R2501 S1#62pmos@550_poly-right##2 S1#62pmos@550_poly-right##3 9.623
R2502 S1#62pmos@550_poly-right##3 S1#62pmos@550_poly-right##4 9.623
R2503 S1#62pmos@550_poly-right##4 S1#62pmos@550_poly-right##5 9.623
R2504 S1#62pmos@550_poly-right##5 S1#62pmos@550_poly-right##6 9.623
R2505 S1#62pmos@550_poly-right##6 S1#62pmos@550_poly-right##7 9.623
R2506 S1#62pmos@550_poly-right##7 S1#62pmos@550_poly-right##8 9.623
R2507 S1#62pmos@550_poly-right##8 S1#62pmos@550_poly-right##9 9.623
R2508 S1#62pmos@550_poly-right##9 S1#62pmos@550_poly-right##10 9.623
R2509 S1#62pmos@550_poly-right##10 S1#62pmos@550_poly-right##11 9.623
R2510 S1#62pmos@550_poly-right##11 S1#62pmos@550_poly-right##12 9.623
R2511 S1#62pmos@550_poly-right##12 S1#62pmos@550_poly-right##13 9.623
R2512 S1#62pmos@550_poly-right##13 S1#62pmos@550_poly-right##14 9.623
R2513 S1#62pmos@550_poly-right##14 S1#62pmos@550_poly-right##15 9.623
R2514 S1#62pmos@550_poly-right##15 S1#62pmos@550_poly-right##16 9.623
R2515 S1#62pmos@550_poly-right##16 S1#62pmos@550_poly-right##17 9.623
R2516 S1#62pmos@550_poly-right##17 S1#62pmos@550_poly-right##18 9.623
R2517 S1#62pmos@550_poly-right##18 S1#62pmos@550_poly-right##19 9.623
R2518 S1#62pmos@550_poly-right##19 S1#62pmos@550_poly-right##20 9.623
R2519 S1#62pmos@550_poly-right##20 S1#62pmos@550_poly-right##21 9.623
R2520 S1#62pmos@550_poly-right##21 S1#62pmos@550_poly-right##22 9.623
R2521 S1#62pmos@550_poly-right##22 S1#63pin@1549_polysilicon-1 9.623
R2522 S1#63pin@1549_polysilicon-1 S1#64nmos@550_poly-right 7.75
R2523 S1 S1##0 6.2
R2524 S1##0 S1#63pin@1549_polysilicon-1 6.2
R2525 D15#3nmos@546_poly-left D15#3nmos@546_poly-left##0 9.92
R2526 D15#3nmos@546_poly-left##0 D15#3nmos@546_poly-left##1 9.92
R2527 D15#3nmos@546_poly-left##1 D15#3nmos@546_poly-left##2 9.92
R2528 D15#3nmos@546_poly-left##2 D15#3nmos@546_poly-left##3 9.92
R2529 D15#3nmos@546_poly-left##3 D15#3nmos@546_poly-left##4 9.92
R2530 D15#3nmos@546_poly-left##4 D15#3nmos@546_poly-left##5 9.92
R2531 D15#3nmos@546_poly-left##5 D15#3nmos@546_poly-left##6 9.92
R2532 D15#3nmos@546_poly-left##6 D15#3nmos@546_poly-left##7 9.92
R2533 D15#3nmos@546_poly-left##7 D15#3nmos@546_poly-left##8 9.92
R2534 D15#3nmos@546_poly-left##8 D15#4pin@1550_polysilicon-1 9.92
R2535 D15#4pin@1550_polysilicon-1 D15#4pin@1550_polysilicon-1##0 9.964
R2536 D15#4pin@1550_polysilicon-1##0 D15#4pin@1550_polysilicon-1##1 9.964
R2537 D15#4pin@1550_polysilicon-1##1 D15#4pin@1550_polysilicon-1##2 9.964
R2538 D15#4pin@1550_polysilicon-1##2 D15#4pin@1550_polysilicon-1##3 9.964
R2539 D15#4pin@1550_polysilicon-1##3 D15#4pin@1550_polysilicon-1##4 9.964
R2540 D15#4pin@1550_polysilicon-1##4 D15#4pin@1550_polysilicon-1##5 9.964
R2541 D15#4pin@1550_polysilicon-1##5 D15#4pin@1550_polysilicon-1##6 9.964
R2542 D15#4pin@1550_polysilicon-1##6 D15#4pin@1550_polysilicon-1##7 9.964
R2543 D15#4pin@1550_polysilicon-1##7 D15#4pin@1550_polysilicon-1##8 9.964
R2544 D15#4pin@1550_polysilicon-1##8 D15#4pin@1550_polysilicon-1##9 9.964
R2545 D15#4pin@1550_polysilicon-1##9 D15#4pin@1550_polysilicon-1##10 9.964
R2546 D15#4pin@1550_polysilicon-1##10 D15#4pin@1550_polysilicon-1##11 9.964
R2547 D15#4pin@1550_polysilicon-1##11 D15#4pin@1550_polysilicon-1##12 9.964
R2548 D15#4pin@1550_polysilicon-1##12 D15#5pmos@547_poly-right 9.964
R2549 D15 D15##0 8.06
R2550 D15##0 D15##1 8.06
R2551 D15##1 D15##2 8.06
R2552 D15##2 D15##3 8.06
R2553 D15##3 D15#4pin@1550_polysilicon-1 8.06
R2554 D14 D14#3contact@2763_metal-1-polysilicon-1 4.576
R2555 net@7212#3contact@2794_metal-1-p-act net@7212#1contact@2757_metal-1-polysilicon-1 4.706
R2556 D13 D13#3contact@2747_metal-1-polysilicon-1 6.838
R2557 D12#0contact@2822_metal-1-metal-2 D12 9.087
R2558 net@7230 net@7230#5contact@2727_metal-1-polysilicon-1 5.07
R2559 S0#57contact@2759_metal-1-polysilicon-1 S0 4.68
R2560 net@7301#4contact@2784_metal-1-n-act net@7301#1contact@2728_metal-1-polysilicon-1 7.254
R2561 D12#3nmos@534_poly-left D12#3nmos@534_poly-left##0 9.723
R2562 D12#3nmos@534_poly-left##0 D12#3nmos@534_poly-left##1 9.723
R2563 D12#3nmos@534_poly-left##1 D12#3nmos@534_poly-left##2 9.723
R2564 D12#3nmos@534_poly-left##2 D12#3nmos@534_poly-left##3 9.723
R2565 D12#3nmos@534_poly-left##3 D12#3nmos@534_poly-left##4 9.723
R2566 D12#3nmos@534_poly-left##4 D12#3nmos@534_poly-left##5 9.723
R2567 D12#3nmos@534_poly-left##5 D12#3nmos@534_poly-left##6 9.723
R2568 D12#3nmos@534_poly-left##6 D12#3nmos@534_poly-left##7 9.723
R2569 D12#3nmos@534_poly-left##7 D12#3nmos@534_poly-left##8 9.723
R2570 D12#3nmos@534_poly-left##8 D12#3nmos@534_poly-left##9 9.723
R2571 D12#3nmos@534_poly-left##9 D12#3nmos@534_poly-left##10 9.723
R2572 D12#3nmos@534_poly-left##10 D12#3nmos@534_poly-left##11 9.723
R2573 D12#3nmos@534_poly-left##11 D12#3nmos@534_poly-left##12 9.723
R2574 D12#3nmos@534_poly-left##12 D12#3nmos@534_poly-left##13 9.723
R2575 D12#3nmos@534_poly-left##13 D12#3nmos@534_poly-left##14 9.723
R2576 D12#3nmos@534_poly-left##14 D12#3nmos@534_poly-left##15 9.723
R2577 D12#3nmos@534_poly-left##15 D12#3nmos@534_poly-left##16 9.723
R2578 D12#3nmos@534_poly-left##16 D12#3nmos@534_poly-left##17 9.723
R2579 D12#3nmos@534_poly-left##17 D12#3nmos@534_poly-left##18 9.723
R2580 D12#3nmos@534_poly-left##18 D12#3nmos@534_poly-left##19 9.723
R2581 D12#3nmos@534_poly-left##19 D12#3nmos@534_poly-left##20 9.723
R2582 D12#3nmos@534_poly-left##20 D12#4pin@1517_polysilicon-1 9.723
R2583 D12#4pin@1517_polysilicon-1 D12#4pin@1517_polysilicon-1##0 8.267
R2584 D12#4pin@1517_polysilicon-1##0 D12#4pin@1517_polysilicon-1##1 8.267
R2585 D12#4pin@1517_polysilicon-1##1 D12#5pmos@535_poly-right 8.267
R2586 D12#0contact@2822_metal-1-metal-2 D12#0contact@2822_metal-1-metal-2##0 8.138
R2587 D12#0contact@2822_metal-1-metal-2##0 D12#0contact@2822_metal-1-metal-2##1 8.138
R2588 D12#0contact@2822_metal-1-metal-2##1 D12#0contact@2822_metal-1-metal-2##2 8.138
R2589 D12#0contact@2822_metal-1-metal-2##2 D12#4pin@1517_polysilicon-1 8.138
R2590 net@7257#16pmos@534_poly-right net@7257#16pmos@534_poly-right##0 9.817
R2591 net@7257#16pmos@534_poly-right##0 net@7257#16pmos@534_poly-right##1 9.817
R2592 net@7257#16pmos@534_poly-right##1 net@7257#16pmos@534_poly-right##2 9.817
R2593 net@7257#16pmos@534_poly-right##2 net@7257#16pmos@534_poly-right##3 9.817
R2594 net@7257#16pmos@534_poly-right##3 net@7257#16pmos@534_poly-right##4 9.817
R2595 net@7257#16pmos@534_poly-right##4 net@7257#16pmos@534_poly-right##5 9.817
R2596 net@7257#16pmos@534_poly-right##5 net@7257#16pmos@534_poly-right##6 9.817
R2597 net@7257#16pmos@534_poly-right##6 net@7257#16pmos@534_poly-right##7 9.817
R2598 net@7257#16pmos@534_poly-right##7 net@7257#16pmos@534_poly-right##8 9.817
R2599 net@7257#16pmos@534_poly-right##8 net@7257#16pmos@534_poly-right##9 9.817
R2600 net@7257#16pmos@534_poly-right##9 net@7257#16pmos@534_poly-right##10 9.817
R2601 net@7257#16pmos@534_poly-right##10 net@7257#3contact@2775_metal-1-polysilicon-1 9.817
R2602 net@7257#3contact@2775_metal-1-polysilicon-1 net@7257#3contact@2775_metal-1-polysilicon-1##0 9.3
R2603 net@7257#3contact@2775_metal-1-polysilicon-1##0 net@7257#3contact@2775_metal-1-polysilicon-1##1 9.3
R2604 net@7257#3contact@2775_metal-1-polysilicon-1##1 net@7257#3contact@2775_metal-1-polysilicon-1##2 9.3
R2605 net@7257#3contact@2775_metal-1-polysilicon-1##2 net@7257#3contact@2775_metal-1-polysilicon-1##3 9.3
R2606 net@7257#3contact@2775_metal-1-polysilicon-1##3 net@7257#3contact@2775_metal-1-polysilicon-1##4 9.3
R2607 net@7257#3contact@2775_metal-1-polysilicon-1##4 net@7257#3contact@2775_metal-1-polysilicon-1##5 9.3
R2608 net@7257#3contact@2775_metal-1-polysilicon-1##5 net@7257#3contact@2775_metal-1-polysilicon-1##6 9.3
R2609 net@7257#3contact@2775_metal-1-polysilicon-1##6 net@7257#3contact@2775_metal-1-polysilicon-1##7 9.3
R2610 net@7257#3contact@2775_metal-1-polysilicon-1##7 net@7257#3contact@2775_metal-1-polysilicon-1##8 9.3
R2611 net@7257#3contact@2775_metal-1-polysilicon-1##8 net@7257#3contact@2775_metal-1-polysilicon-1##9 9.3
R2612 net@7257#3contact@2775_metal-1-polysilicon-1##9 net@7257#3contact@2775_metal-1-polysilicon-1##10 9.3
R2613 net@7257#3contact@2775_metal-1-polysilicon-1##10 net@7257#3contact@2775_metal-1-polysilicon-1##11 9.3
R2614 net@7257#3contact@2775_metal-1-polysilicon-1##11 net@7257#18nmos@535_poly-left 9.3
R2615 net@7212#13pmos@537_poly-right net@7212#13pmos@537_poly-right##0 9.403
R2616 net@7212#13pmos@537_poly-right##0 net@7212#13pmos@537_poly-right##1 9.403
R2617 net@7212#13pmos@537_poly-right##1 net@7212#13pmos@537_poly-right##2 9.403
R2618 net@7212#13pmos@537_poly-right##2 net@7212#13pmos@537_poly-right##3 9.403
R2619 net@7212#13pmos@537_poly-right##3 net@7212#13pmos@537_poly-right##4 9.403
R2620 net@7212#13pmos@537_poly-right##4 net@7212#13pmos@537_poly-right##5 9.403
R2621 net@7212#13pmos@537_poly-right##5 net@7212#13pmos@537_poly-right##6 9.403
R2622 net@7212#13pmos@537_poly-right##6 net@7212#13pmos@537_poly-right##7 9.403
R2623 net@7212#13pmos@537_poly-right##7 net@7212#13pmos@537_poly-right##8 9.403
R2624 net@7212#13pmos@537_poly-right##8 net@7212#13pmos@537_poly-right##9 9.403
R2625 net@7212#13pmos@537_poly-right##9 net@7212#13pmos@537_poly-right##10 9.403
R2626 net@7212#13pmos@537_poly-right##10 net@7212#13pmos@537_poly-right##11 9.403
R2627 net@7212#13pmos@537_poly-right##11 net@7212#13pmos@537_poly-right##12 9.403
R2628 net@7212#13pmos@537_poly-right##12 net@7212#13pmos@537_poly-right##13 9.403
R2629 net@7212#13pmos@537_poly-right##13 net@7212#14pin@1523_polysilicon-1 9.403
R2630 net@7212#14pin@1523_polysilicon-1 net@7212#14pin@1523_polysilicon-1##0 9.765
R2631 net@7212#14pin@1523_polysilicon-1##0 net@7212#14pin@1523_polysilicon-1##1 9.765
R2632 net@7212#14pin@1523_polysilicon-1##1 net@7212#14pin@1523_polysilicon-1##2 9.765
R2633 net@7212#14pin@1523_polysilicon-1##2 net@7212#14pin@1523_polysilicon-1##3 9.765
R2634 net@7212#14pin@1523_polysilicon-1##3 net@7212#14pin@1523_polysilicon-1##4 9.765
R2635 net@7212#14pin@1523_polysilicon-1##4 net@7212#14pin@1523_polysilicon-1##5 9.765
R2636 net@7212#14pin@1523_polysilicon-1##5 net@7212#14pin@1523_polysilicon-1##6 9.765
R2637 net@7212#14pin@1523_polysilicon-1##6 net@7212#14pin@1523_polysilicon-1##7 9.765
R2638 net@7212#14pin@1523_polysilicon-1##7 net@7212#14pin@1523_polysilicon-1##8 9.765
R2639 net@7212#14pin@1523_polysilicon-1##8 net@7212#15nmos@537_poly-left 9.765
R2640 net@7212#1contact@2757_metal-1-polysilicon-1 net@7212#1contact@2757_metal-1-polysilicon-1##0 5.425
R2641 net@7212#1contact@2757_metal-1-polysilicon-1##0 net@7212#14pin@1523_polysilicon-1 5.425
R2642 net@7489 net@7489#1pin@1589_polysilicon-1 7.75
R2643 net@7489#1pin@1589_polysilicon-1 net@7489#1pin@1589_polysilicon-1##0 9.623
R2644 net@7489#1pin@1589_polysilicon-1##0 net@7489#1pin@1589_polysilicon-1##1 9.623
R2645 net@7489#1pin@1589_polysilicon-1##1 net@7489#1pin@1589_polysilicon-1##2 9.623
R2646 net@7489#1pin@1589_polysilicon-1##2 net@7489#1pin@1589_polysilicon-1##3 9.623
R2647 net@7489#1pin@1589_polysilicon-1##3 net@7489#1pin@1589_polysilicon-1##4 9.623
R2648 net@7489#1pin@1589_polysilicon-1##4 net@7489#1pin@1589_polysilicon-1##5 9.623
R2649 net@7489#1pin@1589_polysilicon-1##5 net@7489#1pin@1589_polysilicon-1##6 9.623
R2650 net@7489#1pin@1589_polysilicon-1##6 net@7489#1pin@1589_polysilicon-1##7 9.623
R2651 net@7489#1pin@1589_polysilicon-1##7 net@7489#1pin@1589_polysilicon-1##8 9.623
R2652 net@7489#1pin@1589_polysilicon-1##8 net@7489#1pin@1589_polysilicon-1##9 9.623
R2653 net@7489#1pin@1589_polysilicon-1##9 net@7489#1pin@1589_polysilicon-1##10 9.623
R2654 net@7489#1pin@1589_polysilicon-1##10 net@7489#1pin@1589_polysilicon-1##11 9.623
R2655 net@7489#1pin@1589_polysilicon-1##11 net@7489#1pin@1589_polysilicon-1##12 9.623
R2656 net@7489#1pin@1589_polysilicon-1##12 net@7489#1pin@1589_polysilicon-1##13 9.623
R2657 net@7489#1pin@1589_polysilicon-1##13 net@7489#1pin@1589_polysilicon-1##14 9.623
R2658 net@7489#1pin@1589_polysilicon-1##14 net@7489#1pin@1589_polysilicon-1##15 9.623
R2659 net@7489#1pin@1589_polysilicon-1##15 net@7489#1pin@1589_polysilicon-1##16 9.623
R2660 net@7489#1pin@1589_polysilicon-1##16 net@7489#1pin@1589_polysilicon-1##17 9.623
R2661 net@7489#1pin@1589_polysilicon-1##17 net@7489#1pin@1589_polysilicon-1##18 9.623
R2662 net@7489#1pin@1589_polysilicon-1##18 net@7489#1pin@1589_polysilicon-1##19 9.623
R2663 net@7489#1pin@1589_polysilicon-1##19 net@7489#1pin@1589_polysilicon-1##20 9.623
R2664 net@7489#1pin@1589_polysilicon-1##20 net@7489#1pin@1589_polysilicon-1##21 9.623
R2665 net@7489#1pin@1589_polysilicon-1##21 net@7489#1pin@1589_polysilicon-1##22 9.623
R2666 net@7489#1pin@1589_polysilicon-1##22 net@7489#2nmos@559_poly-right 9.623
R2667 net@7489#3contact@2862_metal-1-polysilicon-1 net@7489#3contact@2862_metal-1-polysilicon-1##0 8.68
R2668 net@7489#3contact@2862_metal-1-polysilicon-1##0 net@7489#3contact@2862_metal-1-polysilicon-1##1 8.68
R2669 net@7489#3contact@2862_metal-1-polysilicon-1##1 net@7489#3contact@2862_metal-1-polysilicon-1##2 8.68
R2670 net@7489#3contact@2862_metal-1-polysilicon-1##2 net@7489#3contact@2862_metal-1-polysilicon-1##3 8.68
R2671 net@7489#3contact@2862_metal-1-polysilicon-1##3 net@7489#1pin@1589_polysilicon-1 8.68
R2672 net@7493 net@7493 0
R2673 net@6668#4nmos@561_poly-left net@6668#4nmos@561_poly-left##0 9.953
R2674 net@6668#4nmos@561_poly-left##0 net@6668#4nmos@561_poly-left##1 9.953
R2675 net@6668#4nmos@561_poly-left##1 net@6668#4nmos@561_poly-left##2 9.953
R2676 net@6668#4nmos@561_poly-left##2 net@6668#4nmos@561_poly-left##3 9.953
R2677 net@6668#4nmos@561_poly-left##3 net@6668#4nmos@561_poly-left##4 9.953
R2678 net@6668#4nmos@561_poly-left##4 net@6668#4nmos@561_poly-left##5 9.953
R2679 net@6668#4nmos@561_poly-left##5 net@6668#4nmos@561_poly-left##6 9.953
R2680 net@6668#4nmos@561_poly-left##6 net@6668#4nmos@561_poly-left##7 9.953
R2681 net@6668#4nmos@561_poly-left##7 net@6668#4nmos@561_poly-left##8 9.953
R2682 net@6668#4nmos@561_poly-left##8 net@6668#4nmos@561_poly-left##9 9.953
R2683 net@6668#4nmos@561_poly-left##9 net@6668#4nmos@561_poly-left##10 9.953
R2684 net@6668#4nmos@561_poly-left##10 net@6668#4nmos@561_poly-left##11 9.953
R2685 net@6668#4nmos@561_poly-left##11 net@6668#4nmos@561_poly-left##12 9.953
R2686 net@6668#4nmos@561_poly-left##12 net@6668#4nmos@561_poly-left##13 9.953
R2687 net@6668#4nmos@561_poly-left##13 net@6668#4nmos@561_poly-left##14 9.953
R2688 net@6668#4nmos@561_poly-left##14 net@6668#4nmos@561_poly-left##15 9.953
R2689 net@6668#4nmos@561_poly-left##15 net@6668#4nmos@561_poly-left##16 9.953
R2690 net@6668#4nmos@561_poly-left##16 net@6668#4nmos@561_poly-left##17 9.953
R2691 net@6668#4nmos@561_poly-left##17 net@6668#5pin@1590_polysilicon-1 9.953
R2692 net@6668#5pin@1590_polysilicon-1 net@6668#5pin@1590_polysilicon-1##0 9.92
R2693 net@6668#5pin@1590_polysilicon-1##0 net@6668#5pin@1590_polysilicon-1##1 9.92
R2694 net@6668#5pin@1590_polysilicon-1##1 net@6668#5pin@1590_polysilicon-1##2 9.92
R2695 net@6668#5pin@1590_polysilicon-1##2 net@6668#5pin@1590_polysilicon-1##3 9.92
R2696 net@6668#5pin@1590_polysilicon-1##3 net@6668#6pmos@562_poly-right 9.92
R2697 net@6668#7contact@2865_metal-1-polysilicon-1 net@6668#7contact@2865_metal-1-polysilicon-1##0 8.525
R2698 net@6668#7contact@2865_metal-1-polysilicon-1##0 net@6668#7contact@2865_metal-1-polysilicon-1##1 8.525
R2699 net@6668#7contact@2865_metal-1-polysilicon-1##1 net@6668#7contact@2865_metal-1-polysilicon-1##2 8.525
R2700 net@6668#7contact@2865_metal-1-polysilicon-1##2 net@6668#5pin@1590_polysilicon-1 8.525
R2701 net@7511 net@7511##0 9.545
R2702 net@7511##0 net@7511##1 9.545
R2703 net@7511##1 net@7511##2 9.545
R2704 net@7511##2 net@7511##3 9.545
R2705 net@7511##3 net@7511##4 9.545
R2706 net@7511##4 net@7511##5 9.545
R2707 net@7511##5 net@7511##6 9.545
R2708 net@7511##6 net@7511##7 9.545
R2709 net@7511##7 net@7511##8 9.545
R2710 net@7511##8 net@7511##9 9.545
R2711 net@7511##9 net@7511##10 9.545
R2712 net@7511##10 net@7511##11 9.545
R2713 net@7511##11 net@7511##12 9.545
R2714 net@7511##12 net@7511##13 9.545
R2715 net@7511##13 net@7511##14 9.545
R2716 net@7511##14 net@7511##15 9.545
R2717 net@7511##15 net@7511##16 9.545
R2718 net@7511##16 net@7511##17 9.545
R2719 net@7511##17 net@7511#1contact@2875_metal-1-polysilicon-1 9.545
R2720 net@7511#1contact@2875_metal-1-polysilicon-1 net@7511#1contact@2875_metal-1-polysilicon-1##0 9.558
R2721 net@7511#1contact@2875_metal-1-polysilicon-1##0 net@7511#1contact@2875_metal-1-polysilicon-1##1 9.558
R2722 net@7511#1contact@2875_metal-1-polysilicon-1##1 net@7511#1contact@2875_metal-1-polysilicon-1##2 9.558
R2723 net@7511#1contact@2875_metal-1-polysilicon-1##2 net@7511#1contact@2875_metal-1-polysilicon-1##3 9.558
R2724 net@7511#1contact@2875_metal-1-polysilicon-1##3 net@7511#1contact@2875_metal-1-polysilicon-1##4 9.558
R2725 net@7511#1contact@2875_metal-1-polysilicon-1##4 net@7511#2nmos@562_poly-left 9.558
R2726 S2#0pmos@564_poly-right S2#0pmos@564_poly-right##0 9.743
R2727 S2#0pmos@564_poly-right##0 S2#0pmos@564_poly-right##1 9.743
R2728 S2#0pmos@564_poly-right##1 S2#0pmos@564_poly-right##2 9.743
R2729 S2#0pmos@564_poly-right##2 S2#0pmos@564_poly-right##3 9.743
R2730 S2#0pmos@564_poly-right##3 S2#0pmos@564_poly-right##4 9.743
R2731 S2#0pmos@564_poly-right##4 S2#0pmos@564_poly-right##5 9.743
R2732 S2#0pmos@564_poly-right##5 S2#0pmos@564_poly-right##6 9.743
R2733 S2#0pmos@564_poly-right##6 S2#0pmos@564_poly-right##7 9.743
R2734 S2#0pmos@564_poly-right##7 S2#0pmos@564_poly-right##8 9.743
R2735 S2#0pmos@564_poly-right##8 S2#0pmos@564_poly-right##9 9.743
R2736 S2#0pmos@564_poly-right##9 S2#0pmos@564_poly-right##10 9.743
R2737 S2#0pmos@564_poly-right##10 S2#0pmos@564_poly-right##11 9.743
R2738 S2#0pmos@564_poly-right##11 S2#0pmos@564_poly-right##12 9.743
R2739 S2#0pmos@564_poly-right##12 S2#0pmos@564_poly-right##13 9.743
R2740 S2#0pmos@564_poly-right##13 S2#0pmos@564_poly-right##14 9.743
R2741 S2#0pmos@564_poly-right##14 S2#0pmos@564_poly-right##15 9.743
R2742 S2#0pmos@564_poly-right##15 S2#0pmos@564_poly-right##16 9.743
R2743 S2#0pmos@564_poly-right##16 S2#0pmos@564_poly-right##17 9.743
R2744 S2#0pmos@564_poly-right##17 S2#0pmos@564_poly-right##18 9.743
R2745 S2#0pmos@564_poly-right##18 S2#0pmos@564_poly-right##19 9.743
R2746 S2#0pmos@564_poly-right##19 S2#1pin@1596_polysilicon-1 9.743
R2747 S2#1pin@1596_polysilicon-1 S2#1pin@1596_polysilicon-1##0 8.525
R2748 S2#1pin@1596_polysilicon-1##0 S2#1pin@1596_polysilicon-1##1 8.525
R2749 S2#1pin@1596_polysilicon-1##1 S2#1pin@1596_polysilicon-1##2 8.525
R2750 S2#1pin@1596_polysilicon-1##2 S2#2nmos@564_poly-left 8.525
R2751 S2#3contact@2877_metal-1-polysilicon-1 S2#3contact@2877_metal-1-polysilicon-1##0 5.425
R2752 S2#3contact@2877_metal-1-polysilicon-1##0 S2#1pin@1596_polysilicon-1 5.425
R2753 net@7500#10pmos@563_poly-right net@7500#11pin@1597_polysilicon-1 6.2
R2754 net@7500#11pin@1597_polysilicon-1 net@7500#11pin@1597_polysilicon-1##0 9.688
R2755 net@7500#11pin@1597_polysilicon-1##0 net@7500#11pin@1597_polysilicon-1##1 9.688
R2756 net@7500#11pin@1597_polysilicon-1##1 net@7500#11pin@1597_polysilicon-1##2 9.688
R2757 net@7500#11pin@1597_polysilicon-1##2 net@7500#11pin@1597_polysilicon-1##3 9.688
R2758 net@7500#11pin@1597_polysilicon-1##3 net@7500#11pin@1597_polysilicon-1##4 9.688
R2759 net@7500#11pin@1597_polysilicon-1##4 net@7500#11pin@1597_polysilicon-1##5 9.688
R2760 net@7500#11pin@1597_polysilicon-1##5 net@7500#11pin@1597_polysilicon-1##6 9.688
R2761 net@7500#11pin@1597_polysilicon-1##6 net@7500#11pin@1597_polysilicon-1##7 9.688
R2762 net@7500#11pin@1597_polysilicon-1##7 net@7500#11pin@1597_polysilicon-1##8 9.688
R2763 net@7500#11pin@1597_polysilicon-1##8 net@7500#11pin@1597_polysilicon-1##9 9.688
R2764 net@7500#11pin@1597_polysilicon-1##9 net@7500#11pin@1597_polysilicon-1##10 9.688
R2765 net@7500#11pin@1597_polysilicon-1##10 net@7500#11pin@1597_polysilicon-1##11 9.688
R2766 net@7500#11pin@1597_polysilicon-1##11 net@7500#11pin@1597_polysilicon-1##12 9.688
R2767 net@7500#11pin@1597_polysilicon-1##12 net@7500#11pin@1597_polysilicon-1##13 9.688
R2768 net@7500#11pin@1597_polysilicon-1##13 net@7500#11pin@1597_polysilicon-1##14 9.688
R2769 net@7500#11pin@1597_polysilicon-1##14 net@7500#11pin@1597_polysilicon-1##15 9.688
R2770 net@7500#11pin@1597_polysilicon-1##15 net@7500#11pin@1597_polysilicon-1##16 9.688
R2771 net@7500#11pin@1597_polysilicon-1##16 net@7500#11pin@1597_polysilicon-1##17 9.688
R2772 net@7500#11pin@1597_polysilicon-1##17 net@7500#11pin@1597_polysilicon-1##18 9.688
R2773 net@7500#11pin@1597_polysilicon-1##18 net@7500#11pin@1597_polysilicon-1##19 9.688
R2774 net@7500#11pin@1597_polysilicon-1##19 net@7500#11pin@1597_polysilicon-1##20 9.688
R2775 net@7500#11pin@1597_polysilicon-1##20 net@7500#11pin@1597_polysilicon-1##21 9.688
R2776 net@7500#11pin@1597_polysilicon-1##21 net@7500#11pin@1597_polysilicon-1##22 9.688
R2777 net@7500#11pin@1597_polysilicon-1##22 net@7500#12nmos@563_poly-right 9.688
R2778 net@7500 net@7500##0 8.68
R2779 net@7500##0 net@7500##1 8.68
R2780 net@7500##1 net@7500##2 8.68
R2781 net@7500##2 net@7500##3 8.68
R2782 net@7500##3 net@7500#11pin@1597_polysilicon-1 8.68
R2783 net@7529 net@7529 0
R2784 net@6967#4nmos@565_poly-left net@6967#4nmos@565_poly-left##0 9.665
R2785 net@6967#4nmos@565_poly-left##0 net@6967#4nmos@565_poly-left##1 9.665
R2786 net@6967#4nmos@565_poly-left##1 net@6967#4nmos@565_poly-left##2 9.665
R2787 net@6967#4nmos@565_poly-left##2 net@6967#4nmos@565_poly-left##3 9.665
R2788 net@6967#4nmos@565_poly-left##3 net@6967#4nmos@565_poly-left##4 9.665
R2789 net@6967#4nmos@565_poly-left##4 net@6967#4nmos@565_poly-left##5 9.665
R2790 net@6967#4nmos@565_poly-left##5 net@6967#4nmos@565_poly-left##6 9.665
R2791 net@6967#4nmos@565_poly-left##6 net@6967#4nmos@565_poly-left##7 9.665
R2792 net@6967#4nmos@565_poly-left##7 net@6967#4nmos@565_poly-left##8 9.665
R2793 net@6967#4nmos@565_poly-left##8 net@6967#4nmos@565_poly-left##9 9.665
R2794 net@6967#4nmos@565_poly-left##9 net@6967#4nmos@565_poly-left##10 9.665
R2795 net@6967#4nmos@565_poly-left##10 net@6967#4nmos@565_poly-left##11 9.665
R2796 net@6967#4nmos@565_poly-left##11 net@6967#4nmos@565_poly-left##12 9.665
R2797 net@6967#4nmos@565_poly-left##12 net@6967#4nmos@565_poly-left##13 9.665
R2798 net@6967#4nmos@565_poly-left##13 net@6967#4nmos@565_poly-left##14 9.665
R2799 net@6967#4nmos@565_poly-left##14 net@6967#4nmos@565_poly-left##15 9.665
R2800 net@6967#4nmos@565_poly-left##15 net@6967#5pin@1598_polysilicon-1 9.665
R2801 net@6967#5pin@1598_polysilicon-1 net@6967#5pin@1598_polysilicon-1##0 9.3
R2802 net@6967#5pin@1598_polysilicon-1##0 net@6967#5pin@1598_polysilicon-1##1 9.3
R2803 net@6967#5pin@1598_polysilicon-1##1 net@6967#5pin@1598_polysilicon-1##2 9.3
R2804 net@6967#5pin@1598_polysilicon-1##2 net@6967#5pin@1598_polysilicon-1##3 9.3
R2805 net@6967#5pin@1598_polysilicon-1##3 net@6967#5pin@1598_polysilicon-1##4 9.3
R2806 net@6967#5pin@1598_polysilicon-1##4 net@6967#5pin@1598_polysilicon-1##5 9.3
R2807 net@6967#5pin@1598_polysilicon-1##5 net@6967#5pin@1598_polysilicon-1##6 9.3
R2808 net@6967#5pin@1598_polysilicon-1##6 net@6967#6pmos@566_poly-right 9.3
R2809 net@6967 net@6967##0 9.688
R2810 net@6967##0 net@6967##1 9.688
R2811 net@6967##1 net@6967##2 9.688
R2812 net@6967##2 net@6967#5pin@1598_polysilicon-1 9.688
R2813 S3#0pmos@565_poly-right S3#0pmos@565_poly-right##0 9.3
R2814 S3#0pmos@565_poly-right##0 S3#0pmos@565_poly-right##1 9.3
R2815 S3#0pmos@565_poly-right##1 S3#0pmos@565_poly-right##2 9.3
R2816 S3#0pmos@565_poly-right##2 S3#0pmos@565_poly-right##3 9.3
R2817 S3#0pmos@565_poly-right##3 S3#0pmos@565_poly-right##4 9.3
R2818 S3#0pmos@565_poly-right##4 S3#0pmos@565_poly-right##5 9.3
R2819 S3#0pmos@565_poly-right##5 S3#0pmos@565_poly-right##6 9.3
R2820 S3#0pmos@565_poly-right##6 S3#0pmos@565_poly-right##7 9.3
R2821 S3#0pmos@565_poly-right##7 S3#0pmos@565_poly-right##8 9.3
R2822 S3#0pmos@565_poly-right##8 S3#1contact@2891_metal-1-polysilicon-1 9.3
R2823 S3#1contact@2891_metal-1-polysilicon-1 S3#1contact@2891_metal-1-polysilicon-1##0 9.713
R2824 S3#1contact@2891_metal-1-polysilicon-1##0 S3#1contact@2891_metal-1-polysilicon-1##1 9.713
R2825 S3#1contact@2891_metal-1-polysilicon-1##1 S3#1contact@2891_metal-1-polysilicon-1##2 9.713
R2826 S3#1contact@2891_metal-1-polysilicon-1##2 S3#1contact@2891_metal-1-polysilicon-1##3 9.713
R2827 S3#1contact@2891_metal-1-polysilicon-1##3 S3#1contact@2891_metal-1-polysilicon-1##4 9.713
R2828 S3#1contact@2891_metal-1-polysilicon-1##4 S3#1contact@2891_metal-1-polysilicon-1##5 9.713
R2829 S3#1contact@2891_metal-1-polysilicon-1##5 S3#1contact@2891_metal-1-polysilicon-1##6 9.713
R2830 S3#1contact@2891_metal-1-polysilicon-1##6 S3#1contact@2891_metal-1-polysilicon-1##7 9.713
R2831 S3#1contact@2891_metal-1-polysilicon-1##7 S3#1contact@2891_metal-1-polysilicon-1##8 9.713
R2832 S3#1contact@2891_metal-1-polysilicon-1##8 S3#1contact@2891_metal-1-polysilicon-1##9 9.713
R2833 S3#1contact@2891_metal-1-polysilicon-1##9 S3#1contact@2891_metal-1-polysilicon-1##10 9.713
R2834 S3#1contact@2891_metal-1-polysilicon-1##10 S3#1contact@2891_metal-1-polysilicon-1##11 9.713
R2835 S3#1contact@2891_metal-1-polysilicon-1##11 S3#1contact@2891_metal-1-polysilicon-1##12 9.713
R2836 S3#1contact@2891_metal-1-polysilicon-1##12 S3#1contact@2891_metal-1-polysilicon-1##13 9.713
R2837 S3#1contact@2891_metal-1-polysilicon-1##13 S3#2nmos@566_poly-left 9.713
R2838 net@7556 net@7556##0 9.817
R2839 net@7556##0 net@7556##1 9.817
R2840 net@7556##1 net@7556##2 9.817
R2841 net@7556##2 net@7556##3 9.817
R2842 net@7556##3 net@7556##4 9.817
R2843 net@7556##4 net@7556##5 9.817
R2844 net@7556##5 net@7556##6 9.817
R2845 net@7556##6 net@7556##7 9.817
R2846 net@7556##7 net@7556##8 9.817
R2847 net@7556##8 net@7556##9 9.817
R2848 net@7556##9 net@7556##10 9.817
R2849 net@7556##10 net@7556#1pin@1604_polysilicon-1 9.817
R2850 net@7556#1pin@1604_polysilicon-1 net@7556#1pin@1604_polysilicon-1##0 9.3
R2851 net@7556#1pin@1604_polysilicon-1##0 net@7556#1pin@1604_polysilicon-1##1 9.3
R2852 net@7556#1pin@1604_polysilicon-1##1 net@7556#1pin@1604_polysilicon-1##2 9.3
R2853 net@7556#1pin@1604_polysilicon-1##2 net@7556#1pin@1604_polysilicon-1##3 9.3
R2854 net@7556#1pin@1604_polysilicon-1##3 net@7556#1pin@1604_polysilicon-1##4 9.3
R2855 net@7556#1pin@1604_polysilicon-1##4 net@7556#1pin@1604_polysilicon-1##5 9.3
R2856 net@7556#1pin@1604_polysilicon-1##5 net@7556#1pin@1604_polysilicon-1##6 9.3
R2857 net@7556#1pin@1604_polysilicon-1##6 net@7556#1pin@1604_polysilicon-1##7 9.3
R2858 net@7556#1pin@1604_polysilicon-1##7 net@7556#1pin@1604_polysilicon-1##8 9.3
R2859 net@7556#1pin@1604_polysilicon-1##8 net@7556#1pin@1604_polysilicon-1##9 9.3
R2860 net@7556#1pin@1604_polysilicon-1##9 net@7556#1pin@1604_polysilicon-1##10 9.3
R2861 net@7556#1pin@1604_polysilicon-1##10 net@7556#1pin@1604_polysilicon-1##11 9.3
R2862 net@7556#1pin@1604_polysilicon-1##11 net@7556#2nmos@568_poly-left 9.3
R2863 net@7556#3contact@2893_metal-1-polysilicon-1 net@7556#3contact@2893_metal-1-polysilicon-1##0 5.425
R2864 net@7556#3contact@2893_metal-1-polysilicon-1##0 net@7556#1pin@1604_polysilicon-1 5.425
R2865 net@7536#10pmos@567_poly-right net@7536#11pin@1605_polysilicon-1 6.2
R2866 net@7536#11pin@1605_polysilicon-1 net@7536#11pin@1605_polysilicon-1##0 9.688
R2867 net@7536#11pin@1605_polysilicon-1##0 net@7536#11pin@1605_polysilicon-1##1 9.688
R2868 net@7536#11pin@1605_polysilicon-1##1 net@7536#11pin@1605_polysilicon-1##2 9.688
R2869 net@7536#11pin@1605_polysilicon-1##2 net@7536#11pin@1605_polysilicon-1##3 9.688
R2870 net@7536#11pin@1605_polysilicon-1##3 net@7536#11pin@1605_polysilicon-1##4 9.688
R2871 net@7536#11pin@1605_polysilicon-1##4 net@7536#11pin@1605_polysilicon-1##5 9.688
R2872 net@7536#11pin@1605_polysilicon-1##5 net@7536#11pin@1605_polysilicon-1##6 9.688
R2873 net@7536#11pin@1605_polysilicon-1##6 net@7536#11pin@1605_polysilicon-1##7 9.688
R2874 net@7536#11pin@1605_polysilicon-1##7 net@7536#11pin@1605_polysilicon-1##8 9.688
R2875 net@7536#11pin@1605_polysilicon-1##8 net@7536#11pin@1605_polysilicon-1##9 9.688
R2876 net@7536#11pin@1605_polysilicon-1##9 net@7536#11pin@1605_polysilicon-1##10 9.688
R2877 net@7536#11pin@1605_polysilicon-1##10 net@7536#11pin@1605_polysilicon-1##11 9.688
R2878 net@7536#11pin@1605_polysilicon-1##11 net@7536#11pin@1605_polysilicon-1##12 9.688
R2879 net@7536#11pin@1605_polysilicon-1##12 net@7536#11pin@1605_polysilicon-1##13 9.688
R2880 net@7536#11pin@1605_polysilicon-1##13 net@7536#11pin@1605_polysilicon-1##14 9.688
R2881 net@7536#11pin@1605_polysilicon-1##14 net@7536#11pin@1605_polysilicon-1##15 9.688
R2882 net@7536#11pin@1605_polysilicon-1##15 net@7536#11pin@1605_polysilicon-1##16 9.688
R2883 net@7536#11pin@1605_polysilicon-1##16 net@7536#11pin@1605_polysilicon-1##17 9.688
R2884 net@7536#11pin@1605_polysilicon-1##17 net@7536#11pin@1605_polysilicon-1##18 9.688
R2885 net@7536#11pin@1605_polysilicon-1##18 net@7536#11pin@1605_polysilicon-1##19 9.688
R2886 net@7536#11pin@1605_polysilicon-1##19 net@7536#11pin@1605_polysilicon-1##20 9.688
R2887 net@7536#11pin@1605_polysilicon-1##20 net@7536#11pin@1605_polysilicon-1##21 9.688
R2888 net@7536#11pin@1605_polysilicon-1##21 net@7536#11pin@1605_polysilicon-1##22 9.688
R2889 net@7536#11pin@1605_polysilicon-1##22 net@7536#12nmos@567_poly-right 9.688
R2890 net@7536 net@7536##0 8.68
R2891 net@7536##0 net@7536##1 8.68
R2892 net@7536##1 net@7536##2 8.68
R2893 net@7536##2 net@7536##3 8.68
R2894 net@7536##3 net@7536#11pin@1605_polysilicon-1 8.68
R2895 Vout Vout 0
R2896 net@7506#11pmos@553_poly-right net@7506#11pmos@553_poly-right##0 9.743
R2897 net@7506#11pmos@553_poly-right##0 net@7506#11pmos@553_poly-right##1 9.743
R2898 net@7506#11pmos@553_poly-right##1 net@7506#11pmos@553_poly-right##2 9.743
R2899 net@7506#11pmos@553_poly-right##2 net@7506#11pmos@553_poly-right##3 9.743
R2900 net@7506#11pmos@553_poly-right##3 net@7506#11pmos@553_poly-right##4 9.743
R2901 net@7506#11pmos@553_poly-right##4 net@7506#11pmos@553_poly-right##5 9.743
R2902 net@7506#11pmos@553_poly-right##5 net@7506#11pmos@553_poly-right##6 9.743
R2903 net@7506#11pmos@553_poly-right##6 net@7506#11pmos@553_poly-right##7 9.743
R2904 net@7506#11pmos@553_poly-right##7 net@7506#11pmos@553_poly-right##8 9.743
R2905 net@7506#11pmos@553_poly-right##8 net@7506#11pmos@553_poly-right##9 9.743
R2906 net@7506#11pmos@553_poly-right##9 net@7506#11pmos@553_poly-right##10 9.743
R2907 net@7506#11pmos@553_poly-right##10 net@7506#11pmos@553_poly-right##11 9.743
R2908 net@7506#11pmos@553_poly-right##11 net@7506#11pmos@553_poly-right##12 9.743
R2909 net@7506#11pmos@553_poly-right##12 net@7506#11pmos@553_poly-right##13 9.743
R2910 net@7506#11pmos@553_poly-right##13 net@7506#11pmos@553_poly-right##14 9.743
R2911 net@7506#11pmos@553_poly-right##14 net@7506#11pmos@553_poly-right##15 9.743
R2912 net@7506#11pmos@553_poly-right##15 net@7506#11pmos@553_poly-right##16 9.743
R2913 net@7506#11pmos@553_poly-right##16 net@7506#11pmos@553_poly-right##17 9.743
R2914 net@7506#11pmos@553_poly-right##17 net@7506#11pmos@553_poly-right##18 9.743
R2915 net@7506#11pmos@553_poly-right##18 net@7506#11pmos@553_poly-right##19 9.743
R2916 net@7506#11pmos@553_poly-right##19 net@7506#12pin@1576_polysilicon-1 9.743
R2917 net@7506#12pin@1576_polysilicon-1 net@7506#12pin@1576_polysilicon-1##0 8.525
R2918 net@7506#12pin@1576_polysilicon-1##0 net@7506#12pin@1576_polysilicon-1##1 8.525
R2919 net@7506#12pin@1576_polysilicon-1##1 net@7506#12pin@1576_polysilicon-1##2 8.525
R2920 net@7506#12pin@1576_polysilicon-1##2 net@7506#13nmos@554_poly-right 8.525
R2921 net@7506 net@7506##0 9.042
R2922 net@7506##0 net@7506##1 9.042
R2923 net@7506##1 net@7506##2 9.042
R2924 net@7506##2 net@7506##3 9.042
R2925 net@7506##3 net@7506##4 9.042
R2926 net@7506##4 net@7506#12pin@1576_polysilicon-1 9.042
R2927 net@7591 net@7591##0 9.704
R2928 net@7591##0 net@7591##1 9.704
R2929 net@7591##1 net@7591##2 9.704
R2930 net@7591##2 net@7591##3 9.704
R2931 net@7591##3 net@7591##4 9.704
R2932 net@7591##4 net@7591##5 9.704
R2933 net@7591##5 net@7591##6 9.704
R2934 net@7591##6 net@7591##7 9.704
R2935 net@7591##7 net@7591##8 9.704
R2936 net@7591##8 net@7591##9 9.704
R2937 net@7591##9 net@7591##10 9.704
R2938 net@7591##10 net@7591##11 9.704
R2939 net@7591##11 net@7591##12 9.704
R2940 net@7591##12 net@7591##13 9.704
R2941 net@7591##13 net@7591##14 9.704
R2942 net@7591##14 net@7591##15 9.704
R2943 net@7591##15 net@7591##16 9.704
R2944 net@7591##16 net@7591##17 9.704
R2945 net@7591##17 net@7591##18 9.704
R2946 net@7591##18 net@7591##19 9.704
R2947 net@7591##19 net@7591##20 9.704
R2948 net@7591##20 net@7591##21 9.704
R2949 net@7591##21 net@7591#1pin@1578_polysilicon-1 9.704
R2950 net@7591#1pin@1578_polysilicon-1 net@7591#1pin@1578_polysilicon-1##0 7.75
R2951 net@7591#1pin@1578_polysilicon-1##0 net@7591#2pmos@554_poly-right 7.75
R2952 net@7591#3contact@2831_metal-1-polysilicon-1 net@7591#3contact@2831_metal-1-polysilicon-1##0 9.3
R2953 net@7591#3contact@2831_metal-1-polysilicon-1##0 net@7591#3contact@2831_metal-1-polysilicon-1##1 9.3
R2954 net@7591#3contact@2831_metal-1-polysilicon-1##1 net@7591#3contact@2831_metal-1-polysilicon-1##2 9.3
R2955 net@7591#3contact@2831_metal-1-polysilicon-1##2 net@7591#3contact@2831_metal-1-polysilicon-1##3 9.3
R2956 net@7591#3contact@2831_metal-1-polysilicon-1##3 net@7591#1pin@1578_polysilicon-1 9.3
R2957 net@7493#4pmos@552_poly-right net@7493#4pmos@552_poly-right##0 8.783
R2958 net@7493#4pmos@552_poly-right##0 net@7493#4pmos@552_poly-right##1 8.783
R2959 net@7493#4pmos@552_poly-right##1 net@7493#4pmos@552_poly-right##2 8.783
R2960 net@7493#4pmos@552_poly-right##2 net@7493#4pmos@552_poly-right##3 8.783
R2961 net@7493#4pmos@552_poly-right##3 net@7493#4pmos@552_poly-right##4 8.783
R2962 net@7493#4pmos@552_poly-right##4 net@7493 8.783
R2963 net@7493 net@7493##0 9.789
R2964 net@7493##0 net@7493##1 9.789
R2965 net@7493##1 net@7493##2 9.789
R2966 net@7493##2 net@7493##3 9.789
R2967 net@7493##3 net@7493##4 9.789
R2968 net@7493##4 net@7493##5 9.789
R2969 net@7493##5 net@7493##6 9.789
R2970 net@7493##6 net@7493##7 9.789
R2971 net@7493##7 net@7493##8 9.789
R2972 net@7493##8 net@7493##9 9.789
R2973 net@7493##9 net@7493##10 9.789
R2974 net@7493##10 net@7493##11 9.789
R2975 net@7493##11 net@7493##12 9.789
R2976 net@7493##12 net@7493##13 9.789
R2977 net@7493##13 net@7493##14 9.789
R2978 net@7493##14 net@7493##15 9.789
R2979 net@7493##15 net@7493##16 9.789
R2980 net@7493##16 net@7493##17 9.789
R2981 net@7493##17 net@7493#6nmos@553_poly-left 9.789
R2982 net@7529#4nmos@555_poly-left net@7529#4nmos@555_poly-left##0 9.756
R2983 net@7529#4nmos@555_poly-left##0 net@7529#4nmos@555_poly-left##1 9.756
R2984 net@7529#4nmos@555_poly-left##1 net@7529#4nmos@555_poly-left##2 9.756
R2985 net@7529#4nmos@555_poly-left##2 net@7529#4nmos@555_poly-left##3 9.756
R2986 net@7529#4nmos@555_poly-left##3 net@7529#4nmos@555_poly-left##4 9.756
R2987 net@7529#4nmos@555_poly-left##4 net@7529#4nmos@555_poly-left##5 9.756
R2988 net@7529#4nmos@555_poly-left##5 net@7529#4nmos@555_poly-left##6 9.756
R2989 net@7529#4nmos@555_poly-left##6 net@7529#4nmos@555_poly-left##7 9.756
R2990 net@7529#4nmos@555_poly-left##7 net@7529#4nmos@555_poly-left##8 9.756
R2991 net@7529#4nmos@555_poly-left##8 net@7529#4nmos@555_poly-left##9 9.756
R2992 net@7529#4nmos@555_poly-left##9 net@7529#4nmos@555_poly-left##10 9.756
R2993 net@7529#4nmos@555_poly-left##10 net@7529#4nmos@555_poly-left##11 9.756
R2994 net@7529#4nmos@555_poly-left##11 net@7529#4nmos@555_poly-left##12 9.756
R2995 net@7529#4nmos@555_poly-left##12 net@7529#4nmos@555_poly-left##13 9.756
R2996 net@7529#4nmos@555_poly-left##13 net@7529#4nmos@555_poly-left##14 9.756
R2997 net@7529#4nmos@555_poly-left##14 net@7529#4nmos@555_poly-left##15 9.756
R2998 net@7529#4nmos@555_poly-left##15 net@7529#5contact@2845_metal-1-polysilicon-1 9.756
R2999 net@7529#5contact@2845_metal-1-polysilicon-1 net@7529#5contact@2845_metal-1-polysilicon-1##0 9.106
R3000 net@7529#5contact@2845_metal-1-polysilicon-1##0 net@7529#5contact@2845_metal-1-polysilicon-1##1 9.106
R3001 net@7529#5contact@2845_metal-1-polysilicon-1##1 net@7529#5contact@2845_metal-1-polysilicon-1##2 9.106
R3002 net@7529#5contact@2845_metal-1-polysilicon-1##2 net@7529#5contact@2845_metal-1-polysilicon-1##3 9.106
R3003 net@7529#5contact@2845_metal-1-polysilicon-1##3 net@7529#5contact@2845_metal-1-polysilicon-1##4 9.106
R3004 net@7529#5contact@2845_metal-1-polysilicon-1##4 net@7529#5contact@2845_metal-1-polysilicon-1##5 9.106
R3005 net@7529#5contact@2845_metal-1-polysilicon-1##5 net@7529#5contact@2845_metal-1-polysilicon-1##6 9.106
R3006 net@7529#5contact@2845_metal-1-polysilicon-1##6 net@7529#6pmos@556_poly-right 9.106
R3007 net@7600 net@7600##0 9.574
R3008 net@7600##0 net@7600##1 9.574
R3009 net@7600##1 net@7600##2 9.574
R3010 net@7600##2 net@7600##3 9.574
R3011 net@7600##3 net@7600##4 9.574
R3012 net@7600##4 net@7600##5 9.574
R3013 net@7600##5 net@7600##6 9.574
R3014 net@7600##6 net@7600##7 9.574
R3015 net@7600##7 net@7600##8 9.574
R3016 net@7600##8 net@7600##9 9.574
R3017 net@7600##9 net@7600##10 9.574
R3018 net@7600##10 net@7600##11 9.574
R3019 net@7600##11 net@7600##12 9.574
R3020 net@7600##12 net@7600##13 9.574
R3021 net@7600##13 net@7600##14 9.574
R3022 net@7600##14 net@7600##15 9.574
R3023 net@7600##15 net@7600#1contact@2846_metal-1-polysilicon-1 9.574
R3024 net@7600#1contact@2846_metal-1-polysilicon-1 net@7600#1contact@2846_metal-1-polysilicon-1##0 9.494
R3025 net@7600#1contact@2846_metal-1-polysilicon-1##0 net@7600#1contact@2846_metal-1-polysilicon-1##1 9.494
R3026 net@7600#1contact@2846_metal-1-polysilicon-1##1 net@7600#1contact@2846_metal-1-polysilicon-1##2 9.494
R3027 net@7600#1contact@2846_metal-1-polysilicon-1##2 net@7600#1contact@2846_metal-1-polysilicon-1##3 9.494
R3028 net@7600#1contact@2846_metal-1-polysilicon-1##3 net@7600#1contact@2846_metal-1-polysilicon-1##4 9.494
R3029 net@7600#1contact@2846_metal-1-polysilicon-1##4 net@7600#1contact@2846_metal-1-polysilicon-1##5 9.494
R3030 net@7600#1contact@2846_metal-1-polysilicon-1##5 net@7600#1contact@2846_metal-1-polysilicon-1##6 9.494
R3031 net@7600#1contact@2846_metal-1-polysilicon-1##6 net@7600#2nmos@556_poly-left 9.494
R3032 net@7591#3contact@2831_metal-1-polysilicon-1 net@7591#3contact@2831_metal-1-polysilicon-1 0
R3033 net@7616 net@7616#1pin@1612_polysilicon-1 7.75
R3034 net@7616#1pin@1612_polysilicon-1 net@7616#1pin@1612_polysilicon-1##0 9.623
R3035 net@7616#1pin@1612_polysilicon-1##0 net@7616#1pin@1612_polysilicon-1##1 9.623
R3036 net@7616#1pin@1612_polysilicon-1##1 net@7616#1pin@1612_polysilicon-1##2 9.623
R3037 net@7616#1pin@1612_polysilicon-1##2 net@7616#1pin@1612_polysilicon-1##3 9.623
R3038 net@7616#1pin@1612_polysilicon-1##3 net@7616#1pin@1612_polysilicon-1##4 9.623
R3039 net@7616#1pin@1612_polysilicon-1##4 net@7616#1pin@1612_polysilicon-1##5 9.623
R3040 net@7616#1pin@1612_polysilicon-1##5 net@7616#1pin@1612_polysilicon-1##6 9.623
R3041 net@7616#1pin@1612_polysilicon-1##6 net@7616#1pin@1612_polysilicon-1##7 9.623
R3042 net@7616#1pin@1612_polysilicon-1##7 net@7616#1pin@1612_polysilicon-1##8 9.623
R3043 net@7616#1pin@1612_polysilicon-1##8 net@7616#1pin@1612_polysilicon-1##9 9.623
R3044 net@7616#1pin@1612_polysilicon-1##9 net@7616#1pin@1612_polysilicon-1##10 9.623
R3045 net@7616#1pin@1612_polysilicon-1##10 net@7616#1pin@1612_polysilicon-1##11 9.623
R3046 net@7616#1pin@1612_polysilicon-1##11 net@7616#1pin@1612_polysilicon-1##12 9.623
R3047 net@7616#1pin@1612_polysilicon-1##12 net@7616#1pin@1612_polysilicon-1##13 9.623
R3048 net@7616#1pin@1612_polysilicon-1##13 net@7616#1pin@1612_polysilicon-1##14 9.623
R3049 net@7616#1pin@1612_polysilicon-1##14 net@7616#1pin@1612_polysilicon-1##15 9.623
R3050 net@7616#1pin@1612_polysilicon-1##15 net@7616#1pin@1612_polysilicon-1##16 9.623
R3051 net@7616#1pin@1612_polysilicon-1##16 net@7616#1pin@1612_polysilicon-1##17 9.623
R3052 net@7616#1pin@1612_polysilicon-1##17 net@7616#1pin@1612_polysilicon-1##18 9.623
R3053 net@7616#1pin@1612_polysilicon-1##18 net@7616#1pin@1612_polysilicon-1##19 9.623
R3054 net@7616#1pin@1612_polysilicon-1##19 net@7616#1pin@1612_polysilicon-1##20 9.623
R3055 net@7616#1pin@1612_polysilicon-1##20 net@7616#1pin@1612_polysilicon-1##21 9.623
R3056 net@7616#1pin@1612_polysilicon-1##21 net@7616#1pin@1612_polysilicon-1##22 9.623
R3057 net@7616#1pin@1612_polysilicon-1##22 net@7616#2nmos@571_poly-right 9.623
R3058 net@7616#3contact@2910_metal-1-polysilicon-1 net@7616#3contact@2910_metal-1-polysilicon-1##0 8.68
R3059 net@7616#3contact@2910_metal-1-polysilicon-1##0 net@7616#3contact@2910_metal-1-polysilicon-1##1 8.68
R3060 net@7616#3contact@2910_metal-1-polysilicon-1##1 net@7616#3contact@2910_metal-1-polysilicon-1##2 8.68
R3061 net@7616#3contact@2910_metal-1-polysilicon-1##2 net@7616#3contact@2910_metal-1-polysilicon-1##3 8.68
R3062 net@7616#3contact@2910_metal-1-polysilicon-1##3 net@7616#1pin@1612_polysilicon-1 8.68
R3063 net@7600#4contact@2902_metal-1-n-act net@7600#4contact@2902_metal-1-n-act 0
R3064 S3#4pmos@569_poly-right S3#4pmos@569_poly-right##0 9.482
R3065 S3#4pmos@569_poly-right##0 S3#4pmos@569_poly-right##1 9.482
R3066 S3#4pmos@569_poly-right##1 S3#4pmos@569_poly-right##2 9.482
R3067 S3#4pmos@569_poly-right##2 S3#4pmos@569_poly-right##3 9.482
R3068 S3#4pmos@569_poly-right##3 S3#4pmos@569_poly-right##4 9.482
R3069 S3#4pmos@569_poly-right##4 S3#4pmos@569_poly-right##5 9.482
R3070 S3#4pmos@569_poly-right##5 S3#4pmos@569_poly-right##6 9.482
R3071 S3#4pmos@569_poly-right##6 S3#4pmos@569_poly-right##7 9.482
R3072 S3#4pmos@569_poly-right##7 S3#4pmos@569_poly-right##8 9.482
R3073 S3#4pmos@569_poly-right##8 S3#4pmos@569_poly-right##9 9.482
R3074 S3#4pmos@569_poly-right##9 S3#4pmos@569_poly-right##10 9.482
R3075 S3#4pmos@569_poly-right##10 S3#4pmos@569_poly-right##11 9.482
R3076 S3#4pmos@569_poly-right##11 S3#4pmos@569_poly-right##12 9.482
R3077 S3#4pmos@569_poly-right##12 S3#4pmos@569_poly-right##13 9.482
R3078 S3#4pmos@569_poly-right##13 S3#4pmos@569_poly-right##14 9.482
R3079 S3#4pmos@569_poly-right##14 S3#4pmos@569_poly-right##15 9.482
R3080 S3#4pmos@569_poly-right##15 S3#1contact@2891_metal-1-polysilicon-1 9.482
R3081 S3#1contact@2891_metal-1-polysilicon-1 S3#1contact@2891_metal-1-polysilicon-1##0 9.688
R3082 S3#1contact@2891_metal-1-polysilicon-1##0 S3#1contact@2891_metal-1-polysilicon-1##1 9.688
R3083 S3#1contact@2891_metal-1-polysilicon-1##1 S3#1contact@2891_metal-1-polysilicon-1##2 9.688
R3084 S3#1contact@2891_metal-1-polysilicon-1##2 S3#1contact@2891_metal-1-polysilicon-1##3 9.688
R3085 S3#1contact@2891_metal-1-polysilicon-1##3 S3#1contact@2891_metal-1-polysilicon-1##4 9.688
R3086 S3#1contact@2891_metal-1-polysilicon-1##4 S3#1contact@2891_metal-1-polysilicon-1##5 9.688
R3087 S3#1contact@2891_metal-1-polysilicon-1##5 S3#1contact@2891_metal-1-polysilicon-1##6 9.688
R3088 S3#1contact@2891_metal-1-polysilicon-1##6 S3#6nmos@570_poly-left 9.688
R3089 S2#5pmos@572_poly-right S2#5pmos@572_poly-right##0 9.871
R3090 S2#5pmos@572_poly-right##0 S2#5pmos@572_poly-right##1 9.871
R3091 S2#5pmos@572_poly-right##1 S2#5pmos@572_poly-right##2 9.871
R3092 S2#5pmos@572_poly-right##2 S2#5pmos@572_poly-right##3 9.871
R3093 S2#5pmos@572_poly-right##3 S2#5pmos@572_poly-right##4 9.871
R3094 S2#5pmos@572_poly-right##4 S2#5pmos@572_poly-right##5 9.871
R3095 S2#5pmos@572_poly-right##5 S2#5pmos@572_poly-right##6 9.871
R3096 S2#5pmos@572_poly-right##6 S2#5pmos@572_poly-right##7 9.871
R3097 S2#5pmos@572_poly-right##7 S2#5pmos@572_poly-right##8 9.871
R3098 S2#5pmos@572_poly-right##8 S2#5pmos@572_poly-right##9 9.871
R3099 S2#5pmos@572_poly-right##9 S2#5pmos@572_poly-right##10 9.871
R3100 S2#5pmos@572_poly-right##10 S2#5pmos@572_poly-right##11 9.871
R3101 S2#5pmos@572_poly-right##11 S2#5pmos@572_poly-right##12 9.871
R3102 S2#5pmos@572_poly-right##12 S2#5pmos@572_poly-right##13 9.871
R3103 S2#5pmos@572_poly-right##13 S2#5pmos@572_poly-right##14 9.871
R3104 S2#5pmos@572_poly-right##14 S2#5pmos@572_poly-right##15 9.871
R3105 S2#5pmos@572_poly-right##15 S2#5pmos@572_poly-right##16 9.871
R3106 S2#5pmos@572_poly-right##16 S2#5pmos@572_poly-right##17 9.871
R3107 S2#5pmos@572_poly-right##17 S2#6pin@1611_polysilicon-1 9.871
R3108 S2#6pin@1611_polysilicon-1 S2#6pin@1611_polysilicon-1##0 8.525
R3109 S2#6pin@1611_polysilicon-1##0 S2#6pin@1611_polysilicon-1##1 8.525
R3110 S2#6pin@1611_polysilicon-1##1 S2#6pin@1611_polysilicon-1##2 8.525
R3111 S2#6pin@1611_polysilicon-1##2 S2#6pin@1611_polysilicon-1##3 8.525
R3112 S2#6pin@1611_polysilicon-1##3 S2#6pin@1611_polysilicon-1##4 8.525
R3113 S2#6pin@1611_polysilicon-1##4 S2#7nmos@572_poly-left 8.525
R3114 S2#8contact@2909_metal-1-polysilicon-1 S2#8contact@2909_metal-1-polysilicon-1##0 5.425
R3115 S2#8contact@2909_metal-1-polysilicon-1##0 S2#6pin@1611_polysilicon-1 5.425
R3116 net@7511#3contact@2912_metal-1-p-act net@7511#3contact@2912_metal-1-p-act 0
R3117 S2#10pmos@574_poly-right S2#10pmos@574_poly-right##0 9.817
R3118 S2#10pmos@574_poly-right##0 S2#10pmos@574_poly-right##1 9.817
R3119 S2#10pmos@574_poly-right##1 S2#10pmos@574_poly-right##2 9.817
R3120 S2#10pmos@574_poly-right##2 S2#10pmos@574_poly-right##3 9.817
R3121 S2#10pmos@574_poly-right##3 S2#10pmos@574_poly-right##4 9.817
R3122 S2#10pmos@574_poly-right##4 S2#10pmos@574_poly-right##5 9.817
R3123 S2#10pmos@574_poly-right##5 S2#10pmos@574_poly-right##6 9.817
R3124 S2#10pmos@574_poly-right##6 S2#10pmos@574_poly-right##7 9.817
R3125 S2#10pmos@574_poly-right##7 S2#10pmos@574_poly-right##8 9.817
R3126 S2#10pmos@574_poly-right##8 S2#10pmos@574_poly-right##9 9.817
R3127 S2#10pmos@574_poly-right##9 S2#10pmos@574_poly-right##10 9.817
R3128 S2#10pmos@574_poly-right##10 S2#10pmos@574_poly-right##11 9.817
R3129 S2#10pmos@574_poly-right##11 S2#10pmos@574_poly-right##12 9.817
R3130 S2#10pmos@574_poly-right##12 S2#10pmos@574_poly-right##13 9.817
R3131 S2#10pmos@574_poly-right##13 S2#10pmos@574_poly-right##14 9.817
R3132 S2#10pmos@574_poly-right##14 S2#10pmos@574_poly-right##15 9.817
R3133 S2#10pmos@574_poly-right##15 S2#10pmos@574_poly-right##16 9.817
R3134 S2#10pmos@574_poly-right##16 S2#10pmos@574_poly-right##17 9.817
R3135 S2#10pmos@574_poly-right##17 S2#10pmos@574_poly-right##18 9.817
R3136 S2#10pmos@574_poly-right##18 S2#10pmos@574_poly-right##19 9.817
R3137 S2#10pmos@574_poly-right##19 S2#11pin@1613_polysilicon-1 9.817
R3138 S2#11pin@1613_polysilicon-1 S2#11pin@1613_polysilicon-1##0 8.138
R3139 S2#11pin@1613_polysilicon-1##0 S2#11pin@1613_polysilicon-1##1 8.138
R3140 S2#11pin@1613_polysilicon-1##1 S2#11pin@1613_polysilicon-1##2 8.138
R3141 S2#11pin@1613_polysilicon-1##2 S2#12nmos@574_poly-right 8.138
R3142 S2#8contact@2909_metal-1-polysilicon-1 S2#8contact@2909_metal-1-polysilicon-1##0 9.644
R3143 S2#8contact@2909_metal-1-polysilicon-1##0 S2#8contact@2909_metal-1-polysilicon-1##1 9.644
R3144 S2#8contact@2909_metal-1-polysilicon-1##1 S2#8contact@2909_metal-1-polysilicon-1##2 9.644
R3145 S2#8contact@2909_metal-1-polysilicon-1##2 S2#8contact@2909_metal-1-polysilicon-1##3 9.644
R3146 S2#8contact@2909_metal-1-polysilicon-1##3 S2#8contact@2909_metal-1-polysilicon-1##4 9.644
R3147 S2#8contact@2909_metal-1-polysilicon-1##4 S2#8contact@2909_metal-1-polysilicon-1##5 9.644
R3148 S2#8contact@2909_metal-1-polysilicon-1##5 S2#8contact@2909_metal-1-polysilicon-1##6 9.644
R3149 S2#8contact@2909_metal-1-polysilicon-1##6 S2#8contact@2909_metal-1-polysilicon-1##7 9.644
R3150 S2#8contact@2909_metal-1-polysilicon-1##7 S2#11pin@1613_polysilicon-1 9.644
R3151 net@7556#3contact@2893_metal-1-polysilicon-1 net@7556#3contact@2893_metal-1-polysilicon-1 0
R3152 S3#12pmos@573_poly-right S3#12pmos@573_poly-right##0 9.623
R3153 S3#12pmos@573_poly-right##0 S3#12pmos@573_poly-right##1 9.623
R3154 S3#12pmos@573_poly-right##1 S3#12pmos@573_poly-right##2 9.623
R3155 S3#12pmos@573_poly-right##2 S3#12pmos@573_poly-right##3 9.623
R3156 S3#12pmos@573_poly-right##3 S3#12pmos@573_poly-right##4 9.623
R3157 S3#12pmos@573_poly-right##4 S3#12pmos@573_poly-right##5 9.623
R3158 S3#12pmos@573_poly-right##5 S3#12pmos@573_poly-right##6 9.623
R3159 S3#12pmos@573_poly-right##6 S3#12pmos@573_poly-right##7 9.623
R3160 S3#12pmos@573_poly-right##7 S3#12pmos@573_poly-right##8 9.623
R3161 S3#12pmos@573_poly-right##8 S3#12pmos@573_poly-right##9 9.623
R3162 S3#12pmos@573_poly-right##9 S3#12pmos@573_poly-right##10 9.623
R3163 S3#12pmos@573_poly-right##10 S3#12pmos@573_poly-right##11 9.623
R3164 S3#12pmos@573_poly-right##11 S3#12pmos@573_poly-right##12 9.623
R3165 S3#12pmos@573_poly-right##12 S3#12pmos@573_poly-right##13 9.623
R3166 S3#12pmos@573_poly-right##13 S3#12pmos@573_poly-right##14 9.623
R3167 S3#12pmos@573_poly-right##14 S3#12pmos@573_poly-right##15 9.623
R3168 S3#12pmos@573_poly-right##15 S3#12pmos@573_poly-right##16 9.623
R3169 S3#12pmos@573_poly-right##16 S3#12pmos@573_poly-right##17 9.623
R3170 S3#12pmos@573_poly-right##17 S3#12pmos@573_poly-right##18 9.623
R3171 S3#12pmos@573_poly-right##18 S3#12pmos@573_poly-right##19 9.623
R3172 S3#12pmos@573_poly-right##19 S3#12pmos@573_poly-right##20 9.623
R3173 S3#12pmos@573_poly-right##20 S3#12pmos@573_poly-right##21 9.623
R3174 S3#12pmos@573_poly-right##21 S3#12pmos@573_poly-right##22 9.623
R3175 S3#12pmos@573_poly-right##22 S3#13pin@1614_polysilicon-1 9.623
R3176 S3#13pin@1614_polysilicon-1 S3#14nmos@573_poly-right 7.75
R3177 S3#1contact@2891_metal-1-polysilicon-1 S3#1contact@2891_metal-1-polysilicon-1##0 6.2
R3178 S3#1contact@2891_metal-1-polysilicon-1##0 S3#13pin@1614_polysilicon-1 6.2
R3179 net@7266#7nmos@569_poly-left net@7266#7nmos@569_poly-left##0 9.92
R3180 net@7266#7nmos@569_poly-left##0 net@7266#7nmos@569_poly-left##1 9.92
R3181 net@7266#7nmos@569_poly-left##1 net@7266#7nmos@569_poly-left##2 9.92
R3182 net@7266#7nmos@569_poly-left##2 net@7266#7nmos@569_poly-left##3 9.92
R3183 net@7266#7nmos@569_poly-left##3 net@7266#7nmos@569_poly-left##4 9.92
R3184 net@7266#7nmos@569_poly-left##4 net@7266#7nmos@569_poly-left##5 9.92
R3185 net@7266#7nmos@569_poly-left##5 net@7266#7nmos@569_poly-left##6 9.92
R3186 net@7266#7nmos@569_poly-left##6 net@7266#7nmos@569_poly-left##7 9.92
R3187 net@7266#7nmos@569_poly-left##7 net@7266#7nmos@569_poly-left##8 9.92
R3188 net@7266#7nmos@569_poly-left##8 net@7266#8pin@1615_polysilicon-1 9.92
R3189 net@7266#8pin@1615_polysilicon-1 net@7266#8pin@1615_polysilicon-1##0 9.964
R3190 net@7266#8pin@1615_polysilicon-1##0 net@7266#8pin@1615_polysilicon-1##1 9.964
R3191 net@7266#8pin@1615_polysilicon-1##1 net@7266#8pin@1615_polysilicon-1##2 9.964
R3192 net@7266#8pin@1615_polysilicon-1##2 net@7266#8pin@1615_polysilicon-1##3 9.964
R3193 net@7266#8pin@1615_polysilicon-1##3 net@7266#8pin@1615_polysilicon-1##4 9.964
R3194 net@7266#8pin@1615_polysilicon-1##4 net@7266#8pin@1615_polysilicon-1##5 9.964
R3195 net@7266#8pin@1615_polysilicon-1##5 net@7266#8pin@1615_polysilicon-1##6 9.964
R3196 net@7266#8pin@1615_polysilicon-1##6 net@7266#8pin@1615_polysilicon-1##7 9.964
R3197 net@7266#8pin@1615_polysilicon-1##7 net@7266#8pin@1615_polysilicon-1##8 9.964
R3198 net@7266#8pin@1615_polysilicon-1##8 net@7266#8pin@1615_polysilicon-1##9 9.964
R3199 net@7266#8pin@1615_polysilicon-1##9 net@7266#8pin@1615_polysilicon-1##10 9.964
R3200 net@7266#8pin@1615_polysilicon-1##10 net@7266#8pin@1615_polysilicon-1##11 9.964
R3201 net@7266#8pin@1615_polysilicon-1##11 net@7266#8pin@1615_polysilicon-1##12 9.964
R3202 net@7266#8pin@1615_polysilicon-1##12 net@7266#9pmos@570_poly-right 9.964
R3203 net@7266 net@7266##0 8.06
R3204 net@7266##0 net@7266##1 8.06
R3205 net@7266##1 net@7266##2 8.06
R3206 net@7266##2 net@7266##3 8.06
R3207 net@7266##3 net@7266#8pin@1615_polysilicon-1 8.06
R3208 net@7511#3contact@2912_metal-1-p-act net@7511#1contact@2875_metal-1-polysilicon-1 4.706
R3209 net@6668 net@6668#7contact@2865_metal-1-polysilicon-1 5.811
R3210 net@6369#4contact@2940_metal-1-metal-2 net@6369 8.06
R3211 net@7529 net@7529#5contact@2845_metal-1-polysilicon-1 5.07
R3212 S2#3contact@2877_metal-1-polysilicon-1 S2#8contact@2909_metal-1-polysilicon-1 4.68
R3213 net@7600#4contact@2902_metal-1-n-act net@7600#1contact@2846_metal-1-polysilicon-1 7.254
R3214 net@6369#7nmos@557_poly-left net@6369#7nmos@557_poly-left##0 9.723
R3215 net@6369#7nmos@557_poly-left##0 net@6369#7nmos@557_poly-left##1 9.723
R3216 net@6369#7nmos@557_poly-left##1 net@6369#7nmos@557_poly-left##2 9.723
R3217 net@6369#7nmos@557_poly-left##2 net@6369#7nmos@557_poly-left##3 9.723
R3218 net@6369#7nmos@557_poly-left##3 net@6369#7nmos@557_poly-left##4 9.723
R3219 net@6369#7nmos@557_poly-left##4 net@6369#7nmos@557_poly-left##5 9.723
R3220 net@6369#7nmos@557_poly-left##5 net@6369#7nmos@557_poly-left##6 9.723
R3221 net@6369#7nmos@557_poly-left##6 net@6369#7nmos@557_poly-left##7 9.723
R3222 net@6369#7nmos@557_poly-left##7 net@6369#7nmos@557_poly-left##8 9.723
R3223 net@6369#7nmos@557_poly-left##8 net@6369#7nmos@557_poly-left##9 9.723
R3224 net@6369#7nmos@557_poly-left##9 net@6369#7nmos@557_poly-left##10 9.723
R3225 net@6369#7nmos@557_poly-left##10 net@6369#7nmos@557_poly-left##11 9.723
R3226 net@6369#7nmos@557_poly-left##11 net@6369#7nmos@557_poly-left##12 9.723
R3227 net@6369#7nmos@557_poly-left##12 net@6369#7nmos@557_poly-left##13 9.723
R3228 net@6369#7nmos@557_poly-left##13 net@6369#7nmos@557_poly-left##14 9.723
R3229 net@6369#7nmos@557_poly-left##14 net@6369#7nmos@557_poly-left##15 9.723
R3230 net@6369#7nmos@557_poly-left##15 net@6369#7nmos@557_poly-left##16 9.723
R3231 net@6369#7nmos@557_poly-left##16 net@6369#7nmos@557_poly-left##17 9.723
R3232 net@6369#7nmos@557_poly-left##17 net@6369#7nmos@557_poly-left##18 9.723
R3233 net@6369#7nmos@557_poly-left##18 net@6369#7nmos@557_poly-left##19 9.723
R3234 net@6369#7nmos@557_poly-left##19 net@6369#7nmos@557_poly-left##20 9.723
R3235 net@6369#7nmos@557_poly-left##20 net@6369#8pin@1582_polysilicon-1 9.723
R3236 net@6369#8pin@1582_polysilicon-1 net@6369#8pin@1582_polysilicon-1##0 8.267
R3237 net@6369#8pin@1582_polysilicon-1##0 net@6369#8pin@1582_polysilicon-1##1 8.267
R3238 net@6369#8pin@1582_polysilicon-1##1 net@6369#9pmos@558_poly-right 8.267
R3239 net@6369#4contact@2940_metal-1-metal-2 net@6369#4contact@2940_metal-1-metal-2##0 8.138
R3240 net@6369#4contact@2940_metal-1-metal-2##0 net@6369#4contact@2940_metal-1-metal-2##1 8.138
R3241 net@6369#4contact@2940_metal-1-metal-2##1 net@6369#4contact@2940_metal-1-metal-2##2 8.138
R3242 net@6369#4contact@2940_metal-1-metal-2##2 net@6369#8pin@1582_polysilicon-1 8.138
R3243 net@7556#16pmos@557_poly-right net@7556#16pmos@557_poly-right##0 9.817
R3244 net@7556#16pmos@557_poly-right##0 net@7556#16pmos@557_poly-right##1 9.817
R3245 net@7556#16pmos@557_poly-right##1 net@7556#16pmos@557_poly-right##2 9.817
R3246 net@7556#16pmos@557_poly-right##2 net@7556#16pmos@557_poly-right##3 9.817
R3247 net@7556#16pmos@557_poly-right##3 net@7556#16pmos@557_poly-right##4 9.817
R3248 net@7556#16pmos@557_poly-right##4 net@7556#16pmos@557_poly-right##5 9.817
R3249 net@7556#16pmos@557_poly-right##5 net@7556#16pmos@557_poly-right##6 9.817
R3250 net@7556#16pmos@557_poly-right##6 net@7556#16pmos@557_poly-right##7 9.817
R3251 net@7556#16pmos@557_poly-right##7 net@7556#16pmos@557_poly-right##8 9.817
R3252 net@7556#16pmos@557_poly-right##8 net@7556#16pmos@557_poly-right##9 9.817
R3253 net@7556#16pmos@557_poly-right##9 net@7556#16pmos@557_poly-right##10 9.817
R3254 net@7556#16pmos@557_poly-right##10 net@7556#3contact@2893_metal-1-polysilicon-1 9.817
R3255 net@7556#3contact@2893_metal-1-polysilicon-1 net@7556#3contact@2893_metal-1-polysilicon-1##0 9.3
R3256 net@7556#3contact@2893_metal-1-polysilicon-1##0 net@7556#3contact@2893_metal-1-polysilicon-1##1 9.3
R3257 net@7556#3contact@2893_metal-1-polysilicon-1##1 net@7556#3contact@2893_metal-1-polysilicon-1##2 9.3
R3258 net@7556#3contact@2893_metal-1-polysilicon-1##2 net@7556#3contact@2893_metal-1-polysilicon-1##3 9.3
R3259 net@7556#3contact@2893_metal-1-polysilicon-1##3 net@7556#3contact@2893_metal-1-polysilicon-1##4 9.3
R3260 net@7556#3contact@2893_metal-1-polysilicon-1##4 net@7556#3contact@2893_metal-1-polysilicon-1##5 9.3
R3261 net@7556#3contact@2893_metal-1-polysilicon-1##5 net@7556#3contact@2893_metal-1-polysilicon-1##6 9.3
R3262 net@7556#3contact@2893_metal-1-polysilicon-1##6 net@7556#3contact@2893_metal-1-polysilicon-1##7 9.3
R3263 net@7556#3contact@2893_metal-1-polysilicon-1##7 net@7556#3contact@2893_metal-1-polysilicon-1##8 9.3
R3264 net@7556#3contact@2893_metal-1-polysilicon-1##8 net@7556#3contact@2893_metal-1-polysilicon-1##9 9.3
R3265 net@7556#3contact@2893_metal-1-polysilicon-1##9 net@7556#3contact@2893_metal-1-polysilicon-1##10 9.3
R3266 net@7556#3contact@2893_metal-1-polysilicon-1##10 net@7556#3contact@2893_metal-1-polysilicon-1##11 9.3
R3267 net@7556#3contact@2893_metal-1-polysilicon-1##11 net@7556#18nmos@558_poly-left 9.3
R3268 net@7511#13pmos@560_poly-right net@7511#13pmos@560_poly-right##0 9.403
R3269 net@7511#13pmos@560_poly-right##0 net@7511#13pmos@560_poly-right##1 9.403
R3270 net@7511#13pmos@560_poly-right##1 net@7511#13pmos@560_poly-right##2 9.403
R3271 net@7511#13pmos@560_poly-right##2 net@7511#13pmos@560_poly-right##3 9.403
R3272 net@7511#13pmos@560_poly-right##3 net@7511#13pmos@560_poly-right##4 9.403
R3273 net@7511#13pmos@560_poly-right##4 net@7511#13pmos@560_poly-right##5 9.403
R3274 net@7511#13pmos@560_poly-right##5 net@7511#13pmos@560_poly-right##6 9.403
R3275 net@7511#13pmos@560_poly-right##6 net@7511#13pmos@560_poly-right##7 9.403
R3276 net@7511#13pmos@560_poly-right##7 net@7511#13pmos@560_poly-right##8 9.403
R3277 net@7511#13pmos@560_poly-right##8 net@7511#13pmos@560_poly-right##9 9.403
R3278 net@7511#13pmos@560_poly-right##9 net@7511#13pmos@560_poly-right##10 9.403
R3279 net@7511#13pmos@560_poly-right##10 net@7511#13pmos@560_poly-right##11 9.403
R3280 net@7511#13pmos@560_poly-right##11 net@7511#13pmos@560_poly-right##12 9.403
R3281 net@7511#13pmos@560_poly-right##12 net@7511#13pmos@560_poly-right##13 9.403
R3282 net@7511#13pmos@560_poly-right##13 net@7511#14pin@1588_polysilicon-1 9.403
R3283 net@7511#14pin@1588_polysilicon-1 net@7511#14pin@1588_polysilicon-1##0 9.765
R3284 net@7511#14pin@1588_polysilicon-1##0 net@7511#14pin@1588_polysilicon-1##1 9.765
R3285 net@7511#14pin@1588_polysilicon-1##1 net@7511#14pin@1588_polysilicon-1##2 9.765
R3286 net@7511#14pin@1588_polysilicon-1##2 net@7511#14pin@1588_polysilicon-1##3 9.765
R3287 net@7511#14pin@1588_polysilicon-1##3 net@7511#14pin@1588_polysilicon-1##4 9.765
R3288 net@7511#14pin@1588_polysilicon-1##4 net@7511#14pin@1588_polysilicon-1##5 9.765
R3289 net@7511#14pin@1588_polysilicon-1##5 net@7511#14pin@1588_polysilicon-1##6 9.765
R3290 net@7511#14pin@1588_polysilicon-1##6 net@7511#14pin@1588_polysilicon-1##7 9.765
R3291 net@7511#14pin@1588_polysilicon-1##7 net@7511#14pin@1588_polysilicon-1##8 9.765
R3292 net@7511#14pin@1588_polysilicon-1##8 net@7511#15nmos@560_poly-left 9.765
R3293 net@7511#1contact@2875_metal-1-polysilicon-1 net@7511#1contact@2875_metal-1-polysilicon-1##0 5.425
R3294 net@7511#1contact@2875_metal-1-polysilicon-1##0 net@7511#14pin@1588_polysilicon-1 5.425
R3295 S2#8contact@2909_metal-1-polysilicon-1 S2#18pin@1654_metal-1 5.72
R3296 S3#1contact@2891_metal-1-polysilicon-1 S3#19pin@1656_metal-1 4.68
R3297 S2#18pin@1654_metal-1 S2#18pin@1654_metal-1##0 7.15
C198 S2#18pin@1654_metal-1##0 0 9.12fF
R3298 S2#18pin@1654_metal-1##0 S2 7.15
R3299 S3#19pin@1656_metal-1 S3#19pin@1656_metal-1##0 7.241
C199 S3#19pin@1656_metal-1##0 0 9.236fF
R3300 S3#19pin@1656_metal-1##0 S3 7.241

* Spice Code nodes in cell cell '16-to-1-Mux{lay}'
VDD VDD 0 DC 3.3
VGND GND 0 DC 0
Vin2 D0 0 PULSE (0 3.3 0n 5n 5n 50n 1600n)
Vin3 D1 0 PULSE (0 3.3 100n 5n 5n 50n 1600n)
Vin4 D2 0 PULSE (0 3.3 200n 5n 5n 50n 1600n)
Vin5 D3 0 PULSE (0 3.3 300n 5n 5n 50n 1600n)
Vin6 D4 0 PULSE (0 3.3 400n 5n 5n 50n 1600n)
Vin7 D5 0 PULSE (0 3.3 500n 5n 5n 50n 1600n)
Vin8 D6 0 PULSE (0 3.3 600n 5n 5n 50n 1600n)
Vin9 D7 0 PULSE (0 3.3 700n 5n 5n 50n 1600n)
Vin10 D8 0 PULSE (0 3.3 800n 5n 5n 50n 1600n)
Vin11 D9 0 PULSE (0 3.3 900n 5n 5n 50n 1600n)
Vin12 D10 0 PULSE (0 3.3 1000n 5n 5n 50n 1600n)
Vin13 D11 0 PULSE (0 3.3 1100n 5n 5n 50n 1600n)
Vin14 D12 0 PULSE (0 3.3 1200n 5n 5n 50n 1600n)
Vin15 D13 0 PULSE (0 3.3 1300n 5n 5n 50n 1600n)
Vin16 D14 0 PULSE (0 3.3 1400n 5n 5n 50n 1600n)
Vin17 D15 0 PULSE (0 3.3 1500n 5n 5n 50n 1600n)
Vin18 S0 0 PULSE (0 3.3 100n 5n 5n 100n 200n)
Vin19 S1 0 PULSE (0 3.3 200n 5n 5n 200n 400n)
Vin20 S2 0 PULSE (0 3.3 400n 5n 5n 400n 800n)
Vin21 S3 0 PULSE (0 3.3 800n 5n 5n 800n 1600n)
.TRAN 0 1600n
.include C:\Users\kille\Desktop\Electric\C5_models.txt
.END
